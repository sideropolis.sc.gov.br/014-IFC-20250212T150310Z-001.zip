Properties of the parts of a building model (IFC4)

# File
Description: IFC4
Time: 2024-12-12T09:11:51
Made in: IfcPlusPlus

# IfcBuildingStorey (3)
Name | LongName | Elevation (cm)
TÉRREO | TÉRREO | 0
FORRO | FORRO | 300
COBERTURA | COBERTURA | 380

# IfcPipeFitting: Bucha de redução longa
In: TÉRREO
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 25 mm - 40 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Bucha de redução longa; Nome: 40 mm - 25 mm; Classe: PVC Esgoto; Tipo: Bucha de redução longa; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Bucha de redução longa
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Bucha de redução longa - 25 mm - 40 mm: 1

# IfcPipeFitting: Cabeceira retangular
In: COBERTURA
Type - PredefinedType: EXIT
AltoQi_Builder - Indicação: 200 mm x 450 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Cabeceira retangular; Nome: 200 mm x 450 mm; Classe: Calha metálica; Tipo: Cabeceira retangular; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Cabeceira retangular
AltoQi_QiBuilder-Itens_Associados - Calha metálica - Cabeceira retangular - 200 mm x 200 mm: 1

# IfcPipeFitting: Joelho 45 (116)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45; Classe: PVC Esgoto; Tipo: Joelho 45
Pset_PipeFittingTypeCommon - Reference: Joelho 45
Name | In | Indicação = Nome | Rede | PVC Esgoto - Joelho 45 - 40 mm
79 x  | TÉRREO | 40 mm | Esgoto | 1
4 x  | TÉRREO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
5 x  | TÉRREO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
22 x  | TÉRREO | 20 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 25 mm: 1
5 x  | TÉRREO | 50 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
 | COBERTURA | 50 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1

# IfcPipeFitting: Joelho 90 (6)
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90; Nome: 20 mm; Classe: PVC Esgoto; Tipo: Joelho 90; Rede: Esgoto
Orcamento - Código SINAPI: 104317
Índices de custos associados - SINAPI: 104317
Pset_PipeFittingTypeCommon - Reference: Joelho 90
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 20 mm: 1

# IfcPipeFitting: Joelho 90- coluna (3)
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- coluna; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Joelho 90- coluna; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Joelho 90- coluna
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
Name
CV-1
CV-5
CV-6

# IfcPipeFitting: Joelho 90- coluna sobe (6)
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- coluna sobe; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Joelho 90- coluna sobe
Pset_PipeFittingTypeCommon - Reference: Joelho 90- coluna sobe
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
Name | Rede
AP-3 | Pluvial
AP-4 | Pluvial
AP-5 | Pluvial
AP-6 | Pluvial
CV-2 | Ventilação
CV-3 | Ventilação

# IfcPipeFitting: Joelho 90- desce (39)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- desce; Classe: PVC Esgoto; Tipo: Joelho 90- desce
Pset_PipeFittingTypeCommon - Reference: Joelho 90- desce
Name | In | Indicação = Nome | Rede | PVC Esgoto - Joelho 90 - 40 mm
29 x  | TÉRREO | 40 mm | Esgoto | 1
6 x  | TÉRREO | 20 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 20 mm: 1
AP-3 | COBERTURA | 50 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
AP-4 | COBERTURA | 50 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
AP-5 | COBERTURA | 50 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
AP-6 | COBERTURA | 50 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1

# IfcPipeFitting: Joelho 90- sobe (36)
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- sobe; Classe: PVC Esgoto; Tipo: Joelho 90- sobe; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Joelho 90- sobe
Name | Indicação = Nome | PVC Esgoto - Joelho 90 - 40 mm
 | 25 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 25 mm: 1
29 x  | 40 mm | 1
6 x  | 20 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 20 mm: 1

# IfcPipeFitting: Junção invertida
In: TÉRREO
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 100 mm x 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção invertida; Nome: 100 mm x 50 mm; Classe: PVC Esgoto; Tipo: Junção invertida; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Junção invertida
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Junção invertida - 100 mm x 50 mm: 1

# IfcPipeFitting: Junção simples (20)
In: TÉRREO
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples; Classe: PVC Esgoto; Tipo: Junção simples
Pset_PipeFittingTypeCommon - Reference: Junção simples
Name | Indicação = Nome | Rede | PVC Esgoto - Anel de borracha - 100mm - 4" | PVC Esgoto - Anel de borracha - 50mm - 2"
8 x  | 100 mm - 50 mm | Esgoto | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
4 x  | 100 mm- 100 mm | Esgoto | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
4 x  | 40 mm x 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 40 mm x 40 mm: 1
2 x  | 50 mm - 50 mm | Esgoto |  | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
2 x  | 50 mm - 50 mm | Ventilação |  | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1

# IfcPipeFitting: Ramais de Ventilação (9)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Ramal de ventilação; Descrição: Ramais de Ventilação; Classe: PVC Esgoto; Tipo: Ramais de Ventilação; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Ramais de Ventilação
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 3; PVC Esgoto - Joelho 90 - 50 mm: 1; PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1
Name | Indicação = Nome
7 x  | 50mm-50mm-45º
2 x  | 50mm-50mm-90º

# IfcPipeFitting: Redução excêntrica - superior
In: TÉRREO
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 100 mm - 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Redução excêntrica- superior; Nome: 100 mm - 50 mm; Classe: PVC Esgoto; Tipo: Redução excêntrica - superior; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Redução excêntrica - superior
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Redução excêntrica - 100 mm - 50 mm: 1

# IfcPipeFitting: Te sanitário- superior, CV-4
In: TÉRREO
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 50 mm -50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te sanitário- superior; Nome: 50 mm -50 mm; Classe: PVC Esgoto; Tipo: Te sanitário- superior; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Te sanitário- superior
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1

# IfcPipeSegment: Calha retangular
In: COBERTURA
Type - PredefinedType: GUTTER
AltoQi_Builder - Altura: 20 cm; Base: 45 cm; Comprimento máximo: 300 cm; Espessura: 0.15 cm; Indicação: 200 x 450; Inclinação: 1; Comprimento: 2352.57 cm
Identificação_Elemento - Nome: 200 mm x 450 mm; Classe: Calha metálica; Tipo: Calha retangular; Rede: Pluvial; Aplicação: Calha retangular aberta
Pset_PipeSegmentTypeCommon - Reference: Calha retangular
Pset_PipeSegmentTypeGutter - Slope: 0.01 rad
AltoQi_QiBuilder-Itens_Associados - Calha metálica - Calha retangular - 200 mm x 200 mm: 2352.57 cm

# IfcPipeSegment: Circular metálico (9)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm; Diâmetro interno: 12.5 cm; Diâmetro: ø4"; Espessura: 0.15 cm; Indicação: 125 mm; Inclinação: 1
Identificação_Elemento - Nome: 125 mm; Classe: Condutor pluvial; Tipo: Circular metálico; Rede: Pluvial; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Circular metálico; InnerDiameter: 12.5 cm; NominalDiameter: ø4"
Name | In | Comprimento (cm) | Condutor pluvial - Circular metálico - 125 mm (cm)
 | TÉRREO | 104.08 | 104.083
 | TÉRREO | 87.47 | 87.469
 | TÉRREO | 71.32 | 71.3245
 | FORRO | 270 | 270
 | FORRO | 250 | 250
 | FORRO | 290 | 290
3 x  | COBERTURA | 80 | 80

# IfcPipeSegment: Tubo rígido c/ ponta e bolsa soldável (48)
In: TÉRREO
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 696 cm; Diâmetro interno: 2.5 cm; Espessura: 0.12 cm; Inclinação: 2
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta e bolsa soldável; Rede: Esgoto; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta e bolsa soldável; InnerDiameter: 2.5 cm
Name | Diâmetro = NominalDiameter | Indicação = Nome | Comprimento (cm) | PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 20mm (cm)
6 x  | ø3/4" | 20 mm | 325.6 | 325.6
 | ø3/4" | 20 mm | 14.83 | 14.8282
 | ø3/4" | 20 mm | 85.05 | 85.049
 | ø3/4" | 20 mm | 4.45 | 4.44573
 | ø3/4" | 20 mm | 7.59 | 7.59392
 | ø3/4" | 20 mm | 3.33 | 3.33212
 | ø3/4" | 20 mm | 5.67 | 5.66523
 | ø3/4" | 20 mm | 57.16 | 57.1573
 | ø3/4" | 20 mm | 8.85 | 8.84724
 | ø3/4" | 20 mm | 21.66 | 21.6585
 | ø3/4" | 20 mm | 47.58 | 47.5832
 | ø3/4" | 20 mm | 39.97 | 39.9658
 | ø3/4" | 20 mm | 323.48 | 323.477
 | ø3/4" | 20 mm | 57.91 | 57.9108
 | ø3/4" | 20 mm | 4.68 | 4.67856
 | ø3/4" | 20 mm | 82.41 | 82.4107
 | ø3/4" | 20 mm | 12.2 | 12.2018
 | ø3/4" | 20 mm | 2.66 | 2.65704
 | ø3/4" | 20 mm | 37.91 | 37.9058
 | ø3/4" | 20 mm | 220.46 | 220.461
 | ø3/4" | 20 mm | 63.3 | 63.3032
 | ø3/4" | 20 mm | 327.09 | 327.086
 | ø1" | 25 mm | 62.8 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 25 mm: 62.8 cm
 | ø1" | 25 mm | 17.5 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 25 mm: 17.5017 cm
 | ø3/4" | 20 mm | 517.68 | 517.678
 | ø3/4" | 20 mm | 40.4 | 40.3967
 | ø3/4" | 20 mm | 138.72 | 138.72
 | ø3/4" | 20 mm | 8.77 | 8.76882
 | ø3/4" | 20 mm | 18.41 | 18.408
 | ø3/4" | 20 mm | 89.11 | 89.1055
 | ø3/4" | 20 mm | 2.33 | 2.33008
 | ø3/4" | 20 mm | 115.55 | 115.547
 | ø3/4" | 20 mm | 11.96 | 11.9579
 | ø3/4" | 20 mm | 422.48 | 422.476
 | ø3/4" | 20 mm | 11.13 | 11.1292
 | ø3/4" | 20 mm | 26.79 | 26.795
 | ø3/4" | 20 mm | 85.68 | 85.6788
 | ø3/4" | 20 mm | 2.22 | 2.22226
 | ø3/4" | 20 mm | 11.08 | 11.0813
 | ø3/4" | 20 mm | 99.07 | 99.0731
 | ø3/4" | 20 mm | 9.68 | 9.67554
 | ø3/4" | 20 mm | 70.86 | 70.8564
 | ø3/4" | 20 mm | 18.36 | 18.3648

# IfcPipeSegment: Tubo rígido c/ ponta lisa (22)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 600 cm; Diâmetro interno: 4.75 cm; Diâmetro: ø2"; Espessura: 0.16 cm; Indicação: 50 mm
Identificação_Elemento - Nome: 50 mm - 2"; Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa; Rede: Ventilação; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa; InnerDiameter: 4.75 cm; NominalDiameter: ø2"
Name | In | Inclinação | Comprimento (cm) | PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2" (cm)
 | TÉRREO | 1 | 26.56 | 26.5597
 | TÉRREO | 1 | 33.48 | 33.4773
 | TÉRREO | 1 | 41.83 | 41.8323
 | TÉRREO | 1 | 112.69 | 112.693
 | TÉRREO | 1 | 75.38 | 75.3752
 | TÉRREO | 1 | 56.6 | 56.6019
 | TÉRREO | 1 | 96.23 | 96.2285
 | TÉRREO | 1 | 102.78 | 102.782
 | TÉRREO | 1 | 5.97 | 5.97205
 | TÉRREO | 1 | 47.53 | 47.5253
 | TÉRREO | 1 | 163.58 | 163.584
 | TÉRREO | 1 | 145.16 | 145.161
 | TÉRREO | 1 | 136 | 135.995
 | TÉRREO | 1 | 58.84 | 58.8371
 | TÉRREO | 1 | 109.94 | 109.938
 | TÉRREO | 1 | 56.66 | 56.6572
 | FORRO | 2 | 361.9 | 361.9
 | FORRO | 2 | 356.9 | 356.9
 | FORRO | 1 | 356.9 | 356.9
 | FORRO | 2 | 352.8 | 352.8
 | FORRO | 1 | 357.2 | 357.2
 | FORRO | 1 | 352.8 | 352.8

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (232)
In: TÉRREO
Type - PredefinedType: RIGIDSEGMENT
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa e luva simples; Rede: Esgoto; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa e luva simples
Name | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | PVC Esgoto - Luva - 40 mm | PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm (cm)
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 42.64 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 42.6364 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 71.5 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 71.4992 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 288.9 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 288.899 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 61.38 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 61.3791 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 45.17 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 45.1715 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 206.24 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 206.242 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 143.28 | 40 mm - 1.1/2" | 1 | 143.284
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9.41 | 40 mm - 1.1/2" | 1 | 9.41362
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 181.44 | 40 mm - 1.1/2" | 1 | 181.441
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 12.97 | 40 mm - 1.1/2" | 1 | 12.968
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 6.15 | 40 mm - 1.1/2" | 1 | 6.14677
6 x  | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 65.6 | 40 mm - 1.1/2" | 1 | 65.6
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 96.32 | 40 mm - 1.1/2" | 1 | 96.3222
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 57.55 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 57.5524 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 45.8 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 45.8047 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 35.08 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 35.0826 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 92.43 | 40 mm - 1.1/2" | 1 | 92.4282
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 205.33 | 40 mm - 1.1/2" | 1 | 205.332
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9 | 40 mm - 1.1/2" | 1 | 9.00487
24 x  | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 60.6 | 40 mm - 1.1/2" | 1 | 60.6
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 395.44 | 40 mm - 1.1/2" | 1 | 395.436
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 152.65 | 40 mm - 1.1/2" | 1 | 152.646
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.75 | 40 mm - 1.1/2" | 1 | 10.7529
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 29.11 | 40 mm - 1.1/2" | 1 | 29.1106
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 61.02 | 40 mm - 1.1/2" | 1 | 61.015
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 15.3 | 40 mm - 1.1/2" | 1 | 15.3033
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 6.4 | 40 mm - 1.1/2" | 1 | 6.39672
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 28.7 | 40 mm - 1.1/2" | 1 | 28.6989
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 14.14 | 40 mm - 1.1/2" | 1 | 14.145
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 94.58 | 40 mm - 1.1/2" | 1 | 94.584
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 79.62 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 79.6172 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9.02 | 40 mm - 1.1/2" | 1 | 9.01777
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 441.42 | 40 mm - 1.1/2" | 1 | 441.421
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9.24 | 40 mm - 1.1/2" | 1 | 9.24198
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 30.42 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 30.4249 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 22.75 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 22.748 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 96.38 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 96.3789 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 1 | 127.75 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 127.751 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 1 | 121.75 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 121.747 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 1 | 298.81 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 298.811 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 100.06 | 40 mm - 1.1/2" | 1 | 100.063
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 147.12 | 40 mm - 1.1/2" | 1 | 147.115
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 21.21 | 40 mm - 1.1/2" | 1 | 21.2107
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 75.41 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 75.4137 cm
2 x  | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 1 | 97.9 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 97.9044 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 1 | 102.5 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 102.504 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 31.98 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 31.9827 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 128.76 | 40 mm - 1.1/2" | 1 | 128.756
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 172.24 | 40 mm - 1.1/2" | 1 | 172.236
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 35.6 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 35.6048 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 64.54 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 64.5421 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 209.5 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 209.5 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 624.04 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 624.044 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 2
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 94.82 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 94.8187 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 32.52 | 40 mm - 1.1/2" | 1 | 32.5233
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 59.99 | 40 mm - 1.1/2" | 1 | 59.9852
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 27.59 | 40 mm - 1.1/2" | 1 | 27.5902
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 57.74 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 57.7378 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 23.21 | 40 mm - 1.1/2" | 1 | 23.2074
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 88.16 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 88.1647 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 58.37 | 40 mm - 1.1/2" | 1 | 58.3685
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 79.65 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 79.6489 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 31.69 | 40 mm - 1.1/2" | 1 | 31.687
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 28.74 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 28.7442 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 169.21 | 40 mm - 1.1/2" | 1 | 169.208
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 25.6 | 40 mm - 1.1/2" | 1 | 25.6047
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 92.22 | 40 mm - 1.1/2" | 1 | 92.219
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 32.72 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 32.7249 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 60.37 | 40 mm - 1.1/2" | 1 | 60.3716
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 95.89 | 40 mm - 1.1/2" | 1 | 95.8932
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 114.82 | 40 mm - 1.1/2" | 1 | 114.817
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 56.84 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 56.8445 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 116.62 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 116.621 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 18.09 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 18.092 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 90.89 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 90.893 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 132.24 | 40 mm - 1.1/2" | 1 | 132.241
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 7.93 | 40 mm - 1.1/2" | 1 | 7.92548
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 151.62 | 40 mm - 1.1/2" | 1 | 151.624
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 325.1 | 40 mm - 1.1/2" | 1 | 325.105
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 233.07 | 40 mm - 1.1/2" | 1 | 233.075
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 91.41 | 40 mm - 1.1/2" | 1 | 91.4107
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.8 | 40 mm - 1.1/2" | 1 | 10.8018
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 201.81 | 40 mm - 1.1/2" | 1 | 201.811
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 448.13 | 40 mm - 1.1/2" | 1 | 448.132
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 231.33 | 40 mm - 1.1/2" | 1 | 231.334
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.62 | 40 mm - 1.1/2" | 1 | 10.6184
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 250.06 | 40 mm - 1.1/2" | 1 | 250.06
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 396.02 | 40 mm - 1.1/2" | 1 | 396.021
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 458.25 | 40 mm - 1.1/2" | 1 | 458.249
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 89.58 | 40 mm - 1.1/2" | 1 | 89.5828
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 50.22 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 50.2179 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 12.09 | 40 mm - 1.1/2" | 1 | 12.0905
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 66.98 | 40 mm - 1.1/2" | 1 | 66.9784
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.49 | 40 mm - 1.1/2" | 1 | 10.4935
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 47.79 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 47.7854 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 20.5 | 40 mm - 1.1/2" | 1 | 20.4955
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 168.54 | 40 mm - 1.1/2" | 1 | 168.538
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 86.08 | 40 mm - 1.1/2" | 1 | 86.0757
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 134.62 | 40 mm - 1.1/2" | 1 | 134.617
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 145.75 | 40 mm - 1.1/2" | 1 | 145.748
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 128.78 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 128.78 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 70.82 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 70.8224 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 7.97 | 40 mm - 1.1/2" | 1 | 7.96587
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 152.67 | 40 mm - 1.1/2" | 1 | 152.672
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 8.31 | 40 mm - 1.1/2" | 1 | 8.3054
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 53.68 | 40 mm - 1.1/2" | 1 | 53.6767
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 18.65 | 40 mm - 1.1/2" | 1 | 18.654
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 17.97 | 40 mm - 1.1/2" | 1 | 17.9735
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 420.8 | 40 mm - 1.1/2" | 1 | 420.8
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 56.58 | 40 mm - 1.1/2" | 1 | 56.5765
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 65.68 | 40 mm - 1.1/2" | 1 | 65.6804
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 279.81 | 40 mm - 1.1/2" | 1 | 279.814
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 47.01 | 40 mm - 1.1/2" | 1 | 47.0091
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 37.83 | 40 mm - 1.1/2" | 1 | 37.8315
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 171.42 | 40 mm - 1.1/2" | 1 | 171.419
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 15.02 | 40 mm - 1.1/2" | 1 | 15.0224
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 31.02 | 40 mm - 1.1/2" | 1 | 31.019
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 13.62 | 40 mm - 1.1/2" | 1 | 13.6244
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 44.61 | 40 mm - 1.1/2" | 1 | 44.6115
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 7.12 | 40 mm - 1.1/2" | 1 | 7.11673
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 6.01 | 40 mm - 1.1/2" | 1 | 6.00857
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 19.33 | 40 mm - 1.1/2" | 1 | 19.3329
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 238.96 | 40 mm - 1.1/2" | 1 | 238.961
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 105.91 | 40 mm - 1.1/2" | 1 | 105.906
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 11.23 | 40 mm - 1.1/2" | 1 | 11.2267
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 128.14 | 40 mm - 1.1/2" | 1 | 128.136
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 409.18 | 40 mm - 1.1/2" | 1 | 409.179
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9.57 | 40 mm - 1.1/2" | 1 | 9.56553
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 721.11 | 40 mm - 1.1/2" | 1 | 721.112
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 81.94 | 40 mm - 1.1/2" | 1 | 81.9422
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 188.51 | 40 mm - 1.1/2" | 1 | 188.511
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 210.47 | 40 mm - 1.1/2" | 1 | 210.472
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 102.29 | 40 mm - 1.1/2" | 1 | 102.286
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 91.2 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 91.1984 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 89.83 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 89.8294 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 54.31 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 54.3136 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 260.18 | 40 mm - 1.1/2" | 1 | 260.182
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 156.78 | 40 mm - 1.1/2" | 1 | 156.78
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 15.04 | 40 mm - 1.1/2" | 1 | 15.0436
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 14.27 | 40 mm - 1.1/2" | 1 | 14.2739
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 112.82 | 40 mm - 1.1/2" | 1 | 112.817
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 102.82 | 40 mm - 1.1/2" | 1 | 102.823
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 85.4 | 40 mm - 1.1/2" | 1 | 85.3958
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 6.32 | 40 mm - 1.1/2" | 1 | 6.31858
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.44 | 40 mm - 1.1/2" | 1 | 10.443
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 192.68 | 40 mm - 1.1/2" | 1 | 192.683
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 146.04 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 146.042 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 65.49 | 40 mm - 1.1/2" | 1 | 65.4894
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 122.96 | 40 mm - 1.1/2" | 1 | 122.964
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 50.45 | 40 mm - 1.1/2" | 1 | 50.4487
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 8.73 | 40 mm - 1.1/2" | 1 | 8.73201
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.02 | 40 mm - 1.1/2" | 1 | 10.017
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 3.79 | 40 mm - 1.1/2" | 1 | 3.79418
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 40.4 | 40 mm - 1.1/2" | 1 | 40.3989
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 140.77 | 40 mm - 1.1/2" | 1 | 140.768
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.13 | 40 mm - 1.1/2" | 1 | 10.132
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 47.64 | 40 mm - 1.1/2" | 1 | 47.6354
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 5.93 | 40 mm - 1.1/2" | 1 | 5.93469
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 150.56 | 40 mm - 1.1/2" | 1 | 150.564
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 48.4 | 40 mm - 1.1/2" | 1 | 48.3991
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 20.14 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 20.1374 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 33.41 | 40 mm - 1.1/2" | 1 | 33.4084
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 74.21 | 40 mm - 1.1/2" | 1 | 74.2127
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 57.34 | 40 mm - 1.1/2" | 1 | 57.3431
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 29.03 | 40 mm - 1.1/2" | 1 | 29.0298
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 6.21 | 40 mm - 1.1/2" | 1 | 6.20681
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 276.18 | 40 mm - 1.1/2" | 1 | 276.184
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 110.63 | 40 mm - 1.1/2" | 1 | 110.633
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 74.57 | 40 mm - 1.1/2" | 1 | 74.5749
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 52.03 | 40 mm - 1.1/2" | 1 | 52.0338
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 172.69 | 40 mm - 1.1/2" | 1 | 172.693
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 697.08 | 40 mm - 1.1/2" | 1 | 697.078
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 50.16 | 40 mm - 1.1/2" | 1 | 50.1574
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 169.75 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 169.754 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 86.75 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 86.7513 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 495.82 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 495.823 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 130.64 | 40 mm - 1.1/2" | 1 | 130.637
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 182.41 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 182.408 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 63.18 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 63.1786 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 110.66 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 110.662 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 496.4 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 496.398 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 14.6 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 14.5968 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 33.03 | 40 mm - 1.1/2" | 1 | 33.0327
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 28.87 | 40 mm - 1.1/2" | 1 | 28.8747
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 8.24 | 40 mm - 1.1/2" | 1 | 8.24397
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 84.15 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 84.1518 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 68 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 67.9998 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 46.74 | 40 mm - 1.1/2" | 1 | 46.7372
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 102.64 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 102.639 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 8.12 | 40 mm - 1.1/2" | 1 | 8.12426
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 81.79 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 81.793 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 21.36 | 40 mm - 1.1/2" | 1 | 21.3571
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 37.16 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 37.1617 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 161.44 | 40 mm - 1.1/2" | 1 | 161.441
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 224.5 | 40 mm - 1.1/2" | 1 | 224.504
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 123.26 | 40 mm - 1.1/2" | 1 | 123.26
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9.49 | 40 mm - 1.1/2" | 1 | 9.49117
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 68.43 | 40 mm - 1.1/2" | 1 | 68.4328
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 238.26 | 40 mm - 1.1/2" | 1 | 238.259
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 18.9 | 40 mm - 1.1/2" | 1 | 18.9017
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 67.86 | 40 mm - 1.1/2" | 1 | 67.8551
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 49.59 | 40 mm - 1.1/2" | 1 | 49.5895
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 316.94 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 316.94 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1

# IfcPipeSegment: Tubos - diâmetro interno comercial (17)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm; Diâmetro interno: 4.4 cm; Diâmetro: ø1 1/2"; Espessura: 0.3 cm; Indicação: 50 mm; Inclinação: 1
Identificação_Elemento - Nome: 50 mm; Classe: PVC rígido soldável; Tipo: Tubos - diâmetro interno comercial; Rede: Pluvial; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubos - diâmetro interno comercial; InnerDiameter: 4.4 cm; NominalDiameter: ø1 1/2"
Name | In | Comprimento (cm) | PVC rígido soldável - Tubos - 50 mm (cm)
4 x  | TÉRREO | 6.7 | 6.69508
4 x  | FORRO | 231.9 | 231.9
 | COBERTURA | 18.45 | 18.4529
 | COBERTURA | 17.82 | 17.8177
4 x  | COBERTURA | 76.9 | 76.9
3 x  | COBERTURA | 31.74 | 31.742

# IfcSanitaryTerminal: Chuveiro Residencial (2)
In: TÉRREO
Type - PredefinedType: SHOWER
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Chuveiro Residencial; Nome: 40mm; Classe: PVC Esgoto; Tipo: Chuveiro Residencial; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Chuveiro Residencial
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo sifonado alt. reg. saída 40 - 100 mm - 40 mm: 1; PVC Esgoto - Curva 90 curta - 40 mm: 1

# IfcSanitaryTerminal: Lavatório Residencial com sifão (29)
In: TÉRREO
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Lavatório Residencial com sifão; Nome: 40mm; Classe: PVC Esgoto; Tipo: Lavatório Residencial com sifão; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório Residencial com sifão
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm

# IfcSanitaryTerminal: Vaso Sanitário c/ curva 90º (6)
In: TÉRREO
Type - PredefinedType: WCSEAT
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Vaso Sanitário c/ curva 90º; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Vaso Sanitário c/ curva 90º; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Vaso Sanitário c/ curva 90º
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1

# IfcStackTerminal: Terminal de ventilação- coluna (6)
In: FORRO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Terminal de ventilação- coluna; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Terminal de ventilação- coluna; Rede: Ventilação
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Terminal de ventilação - 50 mm: 1
Name
CV-1
CV-2
CV-3
CV-4
CV-5
CV-6

# IfcWasteTerminal: Caixa Sifonada (16)
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Comprimento: 15.5 cm; Diâmetro: 15 cm; Indicação: 150x150x50; Posição: Direta
Identificação_Elemento - Aplicação: Caixa sifonada; Descrição: Caixa Sifonada; Nome: 150x150x50; Classe: PVC Esgoto; Tipo: Caixa Sifonada; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Caixa Sifonada
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x150x50: 1; PVC Esgoto - Anel de borracha - 50mm - 2": 1
Name | In
12 x  | TÉRREO
4 x  | COBERTURA

# IfcWasteTerminal: Caixas Inspeção Esgoto Simples (4)
In: TÉRREO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Comprimento: 80 cm; Largura: 80 cm; Indicação: CE- 60x 60cm; Posição: Direta
Identificação_Elemento - Aplicação: Caixa de alvenaria; Descrição: Caixas Inspeção Esgoto Simples; Nome: CE- 60x 60cm; Classe: Caixas de Passagem; Tipo: Caixas Inspeção Esgoto Simples; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Caixas Inspeção Esgoto Simples
AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de inspeção esgoto simples - CE- 60x60 cm: 1

# IfcWasteTerminal: Filtros, FA1
In: TÉRREO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta; Altura do vão livre: 30 cm; Contribuição de esgoto (L/dia): 650; Tempo de detenção (dia): 1; Volume útil estimado (m³): 1.04; Altura total do leito: 120 cm; Comprimento: 127 cm; Largura: 85 cm; Volume (m³): 1.3
Identificação_Elemento - Aplicação: Filtro anaeróbio; Nome: Filtro anaeróbio - concreto; Classe: Unidades de tratamento; Tipo: Filtros; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Filtros
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 254 cm; Unidades de tratamento - Brita - nº4: 1.2954 m3; Unidades de tratamento - Concreto - Concreto: 0.06996 m3

# IfcWasteTerminal: Sumidouros, SU1
In: TÉRREO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta; Altura da camada de brita: 30 cm; Taxa de aplicação diária (m³/m².dia): 0.13; Taxa de percolação (min/m): 100; Contribuição de esgoto (L/dia): 0; Altura: 150 cm
Identificação_Elemento - Aplicação: Sumidouro; Nome: Circular; Classe: Unidades de tratamento; Tipo: Sumidouros; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Sumidouros
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 15 cm; Unidades de tratamento - Argamassa - Argamassa: 0.067858 m3; Unidades de tratamento - Brita - nº3: 0.021206 m3; Unidades de tratamento - Tijolo - Furado: 34

# IfcWasteTerminal: Tanques sépticos, TS1
In: TÉRREO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta; Intervalo entre limpezas: 2 anos; Número de câmaras: Câmara única; Contribuição de esgoto (L/dia): 650; Contribuição de lodo (L/dia): 5; Taxa de acumul. do lodo (dias/intervalo): 105; Tempo de detenção (dia): 1; Volume útil estimado (m³): 2.175; Comprimento: 170 cm; Largura: 85 cm; Profundidade útil: 120 cm; Volume (m³): 1.73
Identificação_Elemento - Aplicação: Tanque séptico; Nome: Tanque séptico - concreto; Classe: Unidades de tratamento; Tipo: Tanques sépticos; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Tanques sépticos
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 120.4 cm; Unidades de tratamento - Alça - Ferro: 1; Unidades de tratamento - Concreto - Concreto: 1.3515 m3; Unidades de tratamento - Tampa - Hermética: 1
