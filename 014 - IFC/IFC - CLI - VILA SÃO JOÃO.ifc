Properties of the parts of a building model (IFC4)

# File
Description: IFC4
Time: 2024-11-25T15:55:53
Made in: IfcPlusPlus

# IfcBuildingStorey (3)
Name | LongName | Elevation (cm)
TÉRREO | TÉRREO | 0
FORRO | FORRO | 300
COBERTURA | COBERTURA | 380

# IfcCondenser: Condensadoras Split (17)
Type - PredefinedType: EVAPORATIVECOOLED
AltoQi_Builder - Indicação: Split; Posição: Direta
Identificação_Elemento - Aplicação: Condensadora; Classe: CLI - Equipamentos; Tipo: Condensadoras Split; Rede: Climatização
Pset_CondenserTypeCommon - Reference: Condensadoras Split
Name | In | Comprimento (cm) | Largura (cm) | Profundidade (cm) | Descrição | Nome | Equipamentos Ar condicionado - Condensadora Split - 12000 BTU/h
9 x  | TÉRREO | 84.4 | 35.3 | 62.2 | Condensadora split 12000 BTU/h | Condensadora 12000 BTU/h | 1
 | TÉRREO | 79 | 28.5 | 54.5 | Condensadora split 24000 BTU/h | Condensadora 24000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Condensadora Split - 24000 BTU/h: 1
2 x  | TÉRREO | 102.3 | 41.3 | 72.4 | Condensadora split 18000 BTU/h | Condensadora 18000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Condensadora Split - 18000 BTU/h: 1
3 x  | COBERTURA | 84.4 | 35.3 | 62.2 | Condensadora split 12000 BTU/h | Condensadora 12000 BTU/h | 1
 | COBERTURA | 102.3 | 41.3 | 72.4 | Condensadora split 18000 BTU/h | Condensadora 18000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Condensadora Split - 18000 BTU/h: 1
 | COBERTURA | 79 | 28.5 | 54.5 | Condensadora split 24000 BTU/h | Condensadora 24000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Condensadora Split - 24000 BTU/h: 1

# IfcDuctFitting: Conexão (33)
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Nome: Conexão; Classe: CLI - Kit linha frigogênica (220 V); Tipo: Conexão; Rede: Climatização
Pset_DuctFittingTypeCommon - Reference: Conexão
AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
Name | In
11 x  | TÉRREO
AC-4 | TÉRREO
AC-1 | FORRO
AC-10 | FORRO
AC-11 | FORRO
AC-12 | FORRO
AC-2 | FORRO
AC-3 | FORRO
AC-4 | FORRO
AC-5 | FORRO
AC-6 | FORRO
AC-7 | FORRO
AC-8 | FORRO
AC-9 | FORRO
4 x  | COBERTURA
AC-10 | COBERTURA
AC-11 | COBERTURA
AC-12 | COBERTURA
AC-13 | COBERTURA
AC-8 | COBERTURA

# IfcEvaporator: Evaporadoras Split (17)
In: TÉRREO
Type - PredefinedType: DIRECTEXPANSION
AltoQi_Builder - Indicação: Split; Posição: Direta
Identificação_Elemento - Aplicação: Evaporadora; Classe: CLI - Equipamentos; Tipo: Evaporadoras Split; Rede: Climatização
Pset_EvaporatorTypeCommon - Reference: Evaporadoras Split
Name | Comprimento (cm) | Largura (cm) | Profundidade (cm) | Descrição | Nome | Equipamentos Ar condicionado - Evaporadora Split - 12000 BTU/h
3 x  | 113 | 38.4 | 37.4 | Evaporadora split 18000 BTU/h | Evaporadora 18000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Evaporadora Split - 18000 BTU/h: 1
12 x  | 88.6 | 33.5 | 31.7 | Evaporadora split 12000 BTU/h | Evaporadora 12000 BTU/h | 1
2 x  | 106.5 | 23 | 29.8 | Evaporadora split 24000 BTU/hh | Evaporadora 24000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Evaporadora Split - 24000 BTU/h: 1

# IfcFlowSegment: Split até 10 metros (desnível máx. 7 m) (41)
Type - PredefinedType: FLEXIBLESEGMENT
AltoQi_Builder - Comprimento máximo: 1000 cm; Espessura: 0.1 cm
Identificação_Elemento - Classe: CLI - Kit linha frigogênica (220 V); Tipo: Split até 10 metros (desnível máx. 7 m); Rede: Climatização; Aplicação: Circular
Pset_DuctSegmentTypeCommon - Reference: Split até 10 metros (desnível máx. 7 m)
Name | In | Diâmetro interno (cm) | Diâmetro | Indicação | Comprimento (cm) | Nome | Segmento de duto - Cabo PP Tetrapolar Isol.PVC - 0,6/1KV - #2.5 mm² (cm) | Segmento de duto - Tubo Isolante Esponjoso - 1/4" (cm) = Segmento de duto - Tubo de cobre flexível - 1/4" (cm) | Segmento de duto - Tubo Isolante Esponjoso - 1/2" (cm) = Segmento de duto - Tubo de cobre flexível - 1/2" (cm)
 | TÉRREO | 4.445 | ø2" | 1/4" e 5/8" S18 | 46.93 | 1/4" e 5/8" - 18.000 Btus | 46.933 | 46.933 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 46.933 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 46.933 cm
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 201.55 | 1/4" e 1/2" - 12.000 Btus | 201.552 | 201.552 | 201.552
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 7 | 1/4" e 1/2" - 12.000 Btus | 7.00293 | 7.00293 | 7.00293
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 201.55 | 1/4" e 1/2" - 12.000 Btus | 201.553 | 201.553 | 201.553
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 7 | 1/4" e 1/2" - 12.000 Btus | 7 | 7 | 7
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 179.75 | 1/4" e 1/2" - 12.000 Btus | 179.755 | 179.755 | 179.755
 | TÉRREO | 4.445 | ø2" | 1/4" e 5/8" S18 | 215.9 | 1/4" e 5/8" - 18.000 Btus | 215.9 | 215.9 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 215.9 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 215.9 cm
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 211.24 | 1/4" e 1/2" - 12.000 Btus | 211.236 | 211.236 | 211.236
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 180.63 | 1/4" e 1/2" - 12.000 Btus | 180.635 | 180.635 | 180.635
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 190.47 | 1/4" e 1/2" - 12.000 Btus | 190.472 | 190.472 | 190.472
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 151.84 | 1/4" e 1/2" - 12.000 Btus | 151.841 | 151.841 | 151.841
2 x  | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 185.11 | 1/4" e 1/2" - 12.000 Btus | 185.109 | 185.109 | 185.109
 | TÉRREO | 5.08 | ø2" | 3/8" e 5/8" S24 | 78.26 | 3/8" e 5/8" - 24.000 Btus | 78.2554 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 78.2554 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 78.2554 cm; Segmento de duto - Tubo Isolante Esponjoso - 3/8": 78.2554 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 78.2554 cm
 | TÉRREO | 5.08 | ø2" | 3/8" e 5/8" S24 | 9.51 | 3/8" e 5/8" - 24.000 Btus | 9.50684 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 9.50684 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 9.50684 cm; Segmento de duto - Tubo Isolante Esponjoso - 3/8": 9.50684 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 9.50684 cm
 | TÉRREO | 4.445 | ø2" | 1/4" e 5/8" S18 | 245.29 | 1/4" e 5/8" - 18.000 Btus | 245.289 | 245.289 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 245.289 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 245.289 cm
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 5.87 | 1/4" e 1/2" - 12.000 Btus | 5.86594 | 5.86594 | 5.86594
 | TÉRREO | 5.08 | ø2" | 3/8" e 5/8" S24 | 8.64 | 3/8" e 5/8" - 24.000 Btus | 8.64199 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 8.64199 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 8.64199 cm; Segmento de duto - Tubo Isolante Esponjoso - 3/8": 8.64199 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 8.64199 cm
 | FORRO | 4.445 | ø2" | 1/4" e 5/8" S18 | 60 | 1/4" e 5/8" - 18.000 Btus | 60 | 60 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 60 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 60 cm
 | FORRO | 4.445 | ø2" | 1/4" e 5/8" S18 | 39.86 | 1/4" e 5/8" - 18.000 Btus | 39.8551 | 39.8551 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 39.8551 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 39.8551 cm
3 x  | FORRO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 60 | 1/4" e 1/2" - 12.000 Btus | 60 | 60 | 60
 | FORRO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 308.79 | 1/4" e 1/2" - 12.000 Btus | 308.79 | 308.79 | 308.79
 | FORRO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 41.93 | 1/4" e 1/2" - 12.000 Btus | 41.9322 | 41.9322 | 41.9322
2 x  | FORRO | 5.08 | ø2" | 3/8" e 5/8" S24 | 60 | 3/8" e 5/8" - 24.000 Btus | 60 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 60 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 60 cm; Segmento de duto - Tubo Isolante Esponjoso - 3/8": 60 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 60 cm
 | FORRO | 5.08 | ø2" | 3/8" e 5/8" S24 | 500.96 | 3/8" e 5/8" - 24.000 Btus | 500.963 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 500.963 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 500.963 cm; Segmento de duto - Tubo Isolante Esponjoso - 3/8": 500.963 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 500.963 cm
 | FORRO | 5.08 | ø2" | 3/8" e 5/8" S24 | 50 | 3/8" e 5/8" - 24.000 Btus | 50 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 50 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 50 cm; Segmento de duto - Tubo Isolante Esponjoso - 3/8": 50 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 50 cm
 | FORRO | 5.08 | ø2" | 3/8" e 5/8" S24 | 51.04 | 3/8" e 5/8" - 24.000 Btus | 51.0395 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 51.0395 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 51.0395 cm; Segmento de duto - Tubo Isolante Esponjoso - 3/8": 51.0395 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 51.0395 cm
 | FORRO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 190.58 | 1/4" e 1/2" - 12.000 Btus | 190.577 | 190.577 | 190.577
 | COBERTURA | 4.445 | ø2" | 1/4" e 5/8" S18 | 60 | 1/4" e 5/8" - 18.000 Btus | 60 | 60 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 60 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 60 cm
 | COBERTURA | 4.445 | ø2" | 1/4" e 5/8" S18 | 139.59 | 1/4" e 5/8" - 18.000 Btus | 139.587 | 139.587 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 139.587 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 139.587 cm
3 x  | COBERTURA | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 80 | 1/4" e 1/2" - 12.000 Btus | 80 | 80 | 80
 | COBERTURA | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 103.59 | 1/4" e 1/2" - 12.000 Btus | 103.592 | 103.592 | 103.592
 | COBERTURA | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 207.74 | 1/4" e 1/2" - 12.000 Btus | 207.74 | 207.74 | 207.74
 | COBERTURA | 5.08 | ø2" | 3/8" e 5/8" S24 | 80 | 3/8" e 5/8" - 24.000 Btus | 80 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 80 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 80 cm; Segmento de duto - Tubo Isolante Esponjoso - 3/8": 80 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 80 cm
 | COBERTURA | 5.08 | ø2" | 3/8" e 5/8" S24 | 346.19 | 3/8" e 5/8" - 24.000 Btus | 346.186 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 346.186 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 346.186 cm; Segmento de duto - Tubo Isolante Esponjoso - 3/8": 346.186 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 346.186 cm
 | COBERTURA | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 392.53 | 1/4" e 1/2" - 12.000 Btus | 392.528 | 392.528 | 392.528
