Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: IFC4
Time: 2024-12-12T09:24:42
Made in: IfcPlusPlus

# IfcBuildingStorey (3)
Name | LongName | Elevation (cm)
TÉRREO | TÉRREO | 0
FORRO | FORRO | 300
COBERTURA | COBERTURA | 380

# IfcCondenser: Condensadoras Split (17)
Type - PredefinedType: EVAPORATIVECOOLED
AltoQi_Builder - Indicação: Split; Posição: Direta
Identificação_Elemento - Aplicação: Condensadora; Classe: CLI - Equipamentos; Tipo: Condensadoras Split; Rede: Climatização
Pset_CondenserTypeCommon - Reference: Condensadoras Split
Name | In | Comprimento (cm) | Largura (cm) | Profundidade (cm) | Descrição | Nome | Equipamentos Ar condicionado - Condensadora Split - 12000 BTU/h
9 x  | TÉRREO | 84.4 | 35.3 | 62.2 | Condensadora split 12000 BTU/h | Condensadora 12000 BTU/h | 1
2 x  | TÉRREO | 102.3 | 41.3 | 72.4 | Condensadora split 18000 BTU/h | Condensadora 18000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Condensadora Split - 18000 BTU/h: 1
 | TÉRREO | 79 | 28.5 | 54.5 | Condensadora split 24000 BTU/h | Condensadora 24000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Condensadora Split - 24000 BTU/h: 1
 | COBERTURA | 79 | 28.5 | 54.5 | Condensadora split 24000 BTU/h | Condensadora 24000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Condensadora Split - 24000 BTU/h: 1
3 x  | COBERTURA | 84.4 | 35.3 | 62.2 | Condensadora split 12000 BTU/h | Condensadora 12000 BTU/h | 1
 | COBERTURA | 102.3 | 41.3 | 72.4 | Condensadora split 18000 BTU/h | Condensadora 18000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Condensadora Split - 18000 BTU/h: 1

# IfcDuctFitting: Conexão (33)
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Nome: Conexão; Classe: CLI - Kit linha frigogênica (220 V); Tipo: Conexão; Rede: Climatização
Pset_DuctFittingTypeCommon - Reference: Conexão
AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
Name | In
11 x  | TÉRREO
AC-4 | TÉRREO
AC-1 | FORRO
AC-10 | FORRO
AC-11 | FORRO
AC-12 | FORRO
AC-2 | FORRO
AC-3 | FORRO
AC-4 | FORRO
AC-5 | FORRO
AC-6 | FORRO
AC-7 | FORRO
AC-8 | FORRO
AC-9 | FORRO
4 x  | COBERTURA
AC-10 | COBERTURA
AC-11 | COBERTURA
AC-12 | COBERTURA
AC-13 | COBERTURA
AC-8 | COBERTURA

# IfcEvaporator: Evaporadoras Split (17)
In: TÉRREO
Type - PredefinedType: DIRECTEXPANSION
AltoQi_Builder - Indicação: Split; Posição: Direta
Identificação_Elemento - Aplicação: Evaporadora; Classe: CLI - Equipamentos; Tipo: Evaporadoras Split; Rede: Climatização
Pset_EvaporatorTypeCommon - Reference: Evaporadoras Split
Name | Comprimento (cm) | Largura (cm) | Profundidade (cm) | Descrição | Nome | Equipamentos Ar condicionado - Evaporadora Split - 12000 BTU/h
12 x  | 88.6 | 33.5 | 31.7 | Evaporadora split 12000 BTU/h | Evaporadora 12000 BTU/h | 1
2 x  | 106.5 | 23 | 29.8 | Evaporadora split 24000 BTU/hh | Evaporadora 24000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Evaporadora Split - 24000 BTU/h: 1
3 x  | 113 | 38.4 | 37.4 | Evaporadora split 18000 BTU/h | Evaporadora 18000 BTU/h | AltoQi_QiBuilder-Itens_Associados - Equipamentos Ar condicionado - Evaporadora Split - 18000 BTU/h: 1

# IfcFlowMeter: Alimentador Predial
In: TÉRREO
Type - PredefinedType: WATERMETER
AltoQi_Builder - Indicação: Com tubo de PVC rígido-1/2"; Posição: Direta
Identificação_Elemento - Aplicação: Alimentador predial; Descrição: Alimentador Predial; Nome: Com tubo de PVC rígido-1/2"; Classe: PVC rígido soldável; Tipo: Alimentador Predial; Rede: Alimentação
Pset_FlowMeterTypeCommon - Reference: Alimentador Predial
AltoQi_QiBuilder-Itens_Associados - Metais - Registro de esfera - 1/2": 1; PVC misto soldável - Colar de tomada em PVC - 1/2": 1; PVC misto soldável - Joelho 90 soldável c/ rosca - 20 mm - 1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 20 mm - 1/2": 1

# IfcFlowMeter: Hidrômetros
In: TÉRREO
Type - PredefinedType: WATERMETER
AltoQi_Builder - Indicação: HIDRÔMETRO; Posição: Direta
Identificação_Elemento - Aplicação: Hidrômetro principal; Descrição: Hidrômetros; Nome: cavalete 1/2"; Classe: PVC rígido soldável; Tipo: Hidrômetros; Rede: Alimentação
Pset_FlowMeterTypeCommon - Reference: Hidrômetros
AltoQi_QiBuilder-Itens_Associados - Metais - Registro esfera borboleta bruto PVC - 1/2": 1; PVC misto soldável - Joelho 90 soldável c/ rosca - 20 mm - 1/2": 3; PVC rígido roscável - Tubos - 1/2": 28 cm; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 20 mm - 1/2": 1; PVC rígido soldável - Joelho 90º soldável - 20 mm: 1; PVC rígido soldável - Tubos - 20 mm: 85 cm

# IfcFlowSegment: Split até 10 metros (desnível máx. 7 m) (41)
Type - PredefinedType: FLEXIBLESEGMENT
AltoQi_Builder - Comprimento máximo: 1000 cm; Espessura: 0.1 cm
Identificação_Elemento - Classe: CLI - Kit linha frigogênica (220 V); Tipo: Split até 10 metros (desnível máx. 7 m); Rede: Climatização; Aplicação: Circular
Pset_DuctSegmentTypeCommon - Reference: Split até 10 metros (desnível máx. 7 m)
Name | In | Diâmetro interno (cm) | Diâmetro | Indicação | Comprimento (cm) | Nome | Segmento de duto - Cabo PP Tetrapolar Isol.PVC - 0,6/1KV - #2.5 mm² (cm) | Segmento de duto - Tubo Isolante Esponjoso - 1/4" (cm) = Segmento de duto - Tubo de cobre flexível - 1/4" (cm) | Segmento de duto - Tubo Isolante Esponjoso - 1/2" (cm) = Segmento de duto - Tubo de cobre flexível - 1/2" (cm)
 | TÉRREO | 5.08 | ø2" | 3/8" e 5/8" S24 | 9.51 | 3/8" e 5/8" - 24.000 Btus | 9.50684 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 3/8": 9.50684 cm; Segmento de duto - Tubo Isolante Esponjoso - 5/8": 9.50684 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 9.50684 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 9.50684 cm
 | TÉRREO | 5.08 | ø2" | 3/8" e 5/8" S24 | 78.26 | 3/8" e 5/8" - 24.000 Btus | 78.2554 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 3/8": 78.2554 cm; Segmento de duto - Tubo Isolante Esponjoso - 5/8": 78.2554 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 78.2554 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 78.2554 cm
 | TÉRREO | 5.08 | ø2" | 3/8" e 5/8" S24 | 8.64 | 3/8" e 5/8" - 24.000 Btus | 8.64199 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 3/8": 8.64199 cm; Segmento de duto - Tubo Isolante Esponjoso - 5/8": 8.64199 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 8.64199 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 8.64199 cm
 | TÉRREO | 4.445 | ø2" | 1/4" e 5/8" S18 | 245.29 | 1/4" e 5/8" - 18.000 Btus | 245.289 | 245.289 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 245.289 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 245.289 cm
 | TÉRREO | 4.445 | ø2" | 1/4" e 5/8" S18 | 46.93 | 1/4" e 5/8" - 18.000 Btus | 46.933 | 46.933 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 46.933 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 46.933 cm
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 7 | 1/4" e 1/2" - 12.000 Btus | 7.00293 | 7.00293 | 7.00293
2 x  | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 185.11 | 1/4" e 1/2" - 12.000 Btus | 185.109 | 185.109 | 185.109
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 201.55 | 1/4" e 1/2" - 12.000 Btus | 201.552 | 201.552 | 201.552
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 201.55 | 1/4" e 1/2" - 12.000 Btus | 201.553 | 201.553 | 201.553
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 151.84 | 1/4" e 1/2" - 12.000 Btus | 151.841 | 151.841 | 151.841
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 211.24 | 1/4" e 1/2" - 12.000 Btus | 211.236 | 211.236 | 211.236
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 179.75 | 1/4" e 1/2" - 12.000 Btus | 179.755 | 179.755 | 179.755
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 7 | 1/4" e 1/2" - 12.000 Btus | 7 | 7 | 7
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 190.47 | 1/4" e 1/2" - 12.000 Btus | 190.472 | 190.472 | 190.472
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 180.63 | 1/4" e 1/2" - 12.000 Btus | 180.635 | 180.635 | 180.635
 | TÉRREO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 5.87 | 1/4" e 1/2" - 12.000 Btus | 5.86594 | 5.86594 | 5.86594
 | TÉRREO | 4.445 | ø2" | 1/4" e 5/8" S18 | 215.9 | 1/4" e 5/8" - 18.000 Btus | 215.9 | 215.9 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 215.9 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 215.9 cm
 | FORRO | 4.445 | ø2" | 1/4" e 5/8" S18 | 60 | 1/4" e 5/8" - 18.000 Btus | 60 | 60 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 60 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 60 cm
3 x  | FORRO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 60 | 1/4" e 1/2" - 12.000 Btus | 60 | 60 | 60
 | FORRO | 4.445 | ø2" | 1/4" e 5/8" S18 | 39.86 | 1/4" e 5/8" - 18.000 Btus | 39.8551 | 39.8551 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 39.8551 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 39.8551 cm
 | FORRO | 5.08 | ø2" | 3/8" e 5/8" S24 | 50 | 3/8" e 5/8" - 24.000 Btus | 50 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 3/8": 50 cm; Segmento de duto - Tubo Isolante Esponjoso - 5/8": 50 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 50 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 50 cm
 | FORRO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 41.93 | 1/4" e 1/2" - 12.000 Btus | 41.9322 | 41.9322 | 41.9322
2 x  | FORRO | 5.08 | ø2" | 3/8" e 5/8" S24 | 60 | 3/8" e 5/8" - 24.000 Btus | 60 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 3/8": 60 cm; Segmento de duto - Tubo Isolante Esponjoso - 5/8": 60 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 60 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 60 cm
 | FORRO | 5.08 | ø2" | 3/8" e 5/8" S24 | 51.04 | 3/8" e 5/8" - 24.000 Btus | 51.0395 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 3/8": 51.0395 cm; Segmento de duto - Tubo Isolante Esponjoso - 5/8": 51.0395 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 51.0395 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 51.0395 cm
 | FORRO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 190.58 | 1/4" e 1/2" - 12.000 Btus | 190.577 | 190.577 | 190.577
 | FORRO | 5.08 | ø2" | 3/8" e 5/8" S24 | 500.96 | 3/8" e 5/8" - 24.000 Btus | 500.963 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 3/8": 500.963 cm; Segmento de duto - Tubo Isolante Esponjoso - 5/8": 500.963 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 500.963 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 500.963 cm
 | FORRO | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 308.79 | 1/4" e 1/2" - 12.000 Btus | 308.79 | 308.79 | 308.79
 | COBERTURA | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 207.74 | 1/4" e 1/2" - 12.000 Btus | 207.74 | 207.74 | 207.74
 | COBERTURA | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 392.53 | 1/4" e 1/2" - 12.000 Btus | 392.528 | 392.528 | 392.528
3 x  | COBERTURA | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 80 | 1/4" e 1/2" - 12.000 Btus | 80 | 80 | 80
 | COBERTURA | 5.08 | ø2" | 3/8" e 5/8" S24 | 346.19 | 3/8" e 5/8" - 24.000 Btus | 346.186 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 3/8": 346.186 cm; Segmento de duto - Tubo Isolante Esponjoso - 5/8": 346.186 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 346.186 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 346.186 cm
 | COBERTURA | 3.81 | ø1 1/2" | 1/4" e 1/2" S12 | 103.59 | 1/4" e 1/2" - 12.000 Btus | 103.592 | 103.592 | 103.592
 | COBERTURA | 5.08 | ø2" | 3/8" e 5/8" S24 | 80 | 3/8" e 5/8" - 24.000 Btus | 80 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 3/8": 80 cm; Segmento de duto - Tubo Isolante Esponjoso - 5/8": 80 cm; Segmento de duto - Tubo de cobre flexível - 3/8": 80 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 80 cm
 | COBERTURA | 4.445 | ø2" | 1/4" e 5/8" S18 | 60 | 1/4" e 5/8" - 18.000 Btus | 60 | 60 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 60 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 60 cm
 | COBERTURA | 4.445 | ø2" | 1/4" e 5/8" S18 | 139.59 | 1/4" e 5/8" - 18.000 Btus | 139.587 | 139.587 | AltoQi_QiBuilder-Itens_Associados - Segmento de duto - Tubo Isolante Esponjoso - 5/8": 139.587 cm; Segmento de duto - Tubo de cobre flexível - 5/8": 139.587 cm

# IfcPipeFitting: Bucha de redução longa
In: TÉRREO
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 25 mm - 40 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Bucha de redução longa; Nome: 40 mm - 25 mm; Classe: PVC Esgoto; Tipo: Bucha de redução longa; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Bucha de redução longa
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Bucha de redução longa - 25 mm - 40 mm: 1

# IfcPipeFitting: Cabeceira retangular
In: COBERTURA
Type - PredefinedType: EXIT
AltoQi_Builder - Indicação: 200 mm x 450 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Cabeceira retangular; Nome: 200 mm x 450 mm; Classe: Calha metálica; Tipo: Cabeceira retangular; Rede: Pluvial
Pset_PipeFittingTypeCommon - Reference: Cabeceira retangular
AltoQi_QiBuilder-Itens_Associados - Calha metálica - Cabeceira retangular - 200 mm x 200 mm: 1

# IfcPipeFitting: Curva 90 soldável (183)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 soldável; Classe: PVC rígido soldável; Tipo: Curva 90 soldável
Pset_PipeFittingTypeCommon - Reference: Curva 90 soldável
Name | In | Indicação = Nome | Rede | PVC rígido soldável - Curva 90 soldável - 25 mm
3 x  | TÉRREO | 20 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 20 mm: 1
89 x  | TÉRREO | 25 mm | Água fria | 1
9 x  | TÉRREO | 20 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 20 mm: 1
5 x  | TÉRREO | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 50 mm: 1
AL-1 | TÉRREO | 20 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 20 mm: 1
2 x  | FORRO | 20 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 20 mm: 1
5 x  | FORRO | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 60 mm: 1
13 x  | FORRO | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
AF-1 | FORRO | 25 mm | Água fria | 1
AF-10 | FORRO | 25 mm | Água fria | 1
AF-11 | FORRO | 25 mm | Água fria | 1
AF-12 | FORRO | 25 mm | Água fria | 1
AF-13 | FORRO | 25 mm | Água fria | 1
AF-14 | FORRO | 25 mm | Água fria | 1
AF-15 | FORRO | 25 mm | Água fria | 1
AF-16 | FORRO | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 50 mm: 1
AF-17 | FORRO | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 50 mm: 1
AF-18 | FORRO | 25 mm | Água fria | 1
AF-19 | FORRO | 25 mm | Água fria | 1
AF-2 | FORRO | 25 mm | Água fria | 1
AF-20 | FORRO | 25 mm | Água fria | 1
AF-21 | FORRO | 25 mm | Água fria | 1
AF-22 | FORRO | 25 mm | Água fria | 1
AF-23 | FORRO | 25 mm | Água fria | 1
AF-24 | FORRO | 25 mm | Água fria | 1
AF-25 | FORRO | 25 mm | Água fria | 1
AF-26 | FORRO | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 50 mm: 1
AF-27 | FORRO | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
AF-28 | FORRO | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 60 mm: 1
AF-29 | FORRO | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 60 mm: 1
AF-3 | FORRO | 25 mm | Água fria | 1
AF-30 | FORRO | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
AF-31 | FORRO | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
AF-32 | FORRO | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 60 mm: 1
AF-33 | FORRO | 25 mm | Água fria | 1
AF-4 | FORRO | 25 mm | Água fria | 1
AF-5 | FORRO | 25 mm | Água fria | 1
AF-6 | FORRO | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 50 mm: 1
AF-7 | FORRO | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 50 mm: 1
AF-8 | FORRO | 25 mm | Água fria | 1
AF-9 | FORRO | 25 mm | Água fria | 1
AL-1 | FORRO | 20 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 20 mm: 1
AL-2 | FORRO | 20 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 20 mm: 1
5 x  | COBERTURA | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 60 mm: 1
4 x  | COBERTURA | 20 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 20 mm: 1
5 x  | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
AF-27 | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
AF-28 | COBERTURA | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 60 mm: 1
AF-29 | COBERTURA | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 60 mm: 1
AF-30 | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
AF-31 | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
AF-32 | COBERTURA | 60 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 60 mm: 1
AL-2 | COBERTURA | 20 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 20 mm: 1

# IfcPipeFitting: Curva de transposição (4)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: CT; Posição: Direta
Identificação_Elemento - Aplicação: Curva de transposição; Descrição: Curva de transposição; Classe: PVC rígido soldável; Tipo: Curva de transposição; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Curva de transposição
Name | In | Nome
2 x  | TÉRREO | 25 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva de transposição - 25 mm: 1
2 x  | FORRO | 32 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva de transposição - 32 mm: 1

# IfcPipeFitting: Joelho 45 (116)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45; Classe: PVC Esgoto; Tipo: Joelho 45
Pset_PipeFittingTypeCommon - Reference: Joelho 45
Name | In | Indicação = Nome | Rede | PVC Esgoto - Joelho 45 - 40 mm
22 x  | TÉRREO | 20 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 25 mm: 1
79 x  | TÉRREO | 40 mm | Esgoto | 1
5 x  | TÉRREO | 50 mm | Ventilação | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
4 x  | TÉRREO | 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 45 - 100 mm: 1
5 x  | TÉRREO | 50 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1
 | COBERTURA | 50 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 45 - 50 mm: 1

# IfcPipeFitting: Joelho 45 soldável (4)
In: FORRO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 32 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45 soldável; Nome: 32 mm; Classe: PVC rígido soldável; Tipo: Joelho 45 soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Joelho 45 soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 32 mm: 1

# IfcPipeFitting: Joelho 90 (6)
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90; Nome: 20 mm; Classe: PVC Esgoto; Tipo: Joelho 90; Rede: Esgoto
Orcamento - Código SINAPI: 104317
Índices de custos associados - SINAPI: 104317
Pset_PipeFittingTypeCommon - Reference: Joelho 90
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 20 mm: 1

# IfcPipeFitting: Joelho 90 soldável (59)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90 soldável; Classe: PVC rígido soldável; Tipo: Joelho 90 soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Joelho 90 soldável
Name | In | Indicação = Nome | Fabricante | Preço | PVC rígido soldável - Joelho 90º soldável - 25 mm
42 x  | TÉRREO | 25 mm | Teste | 12 | 1
9 x  | TÉRREO | 50 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-16 | TÉRREO | 50 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-17 | TÉRREO | 50 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-33 | TÉRREO | 25 mm | Teste | 12 | 1
5 x  | COBERTURA | 25 mm | Teste | 12 | 1

# IfcPipeFitting: Joelho 90- coluna (3)
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- coluna; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Joelho 90- coluna; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Joelho 90- coluna
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
Name
CV-1
CV-5
CV-6

# IfcPipeFitting: Joelho 90- coluna sobe (6)
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- coluna sobe; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Joelho 90- coluna sobe
Pset_PipeFittingTypeCommon - Reference: Joelho 90- coluna sobe
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
Name | Rede
AP-3 | Pluvial
AP-4 | Pluvial
AP-5 | Pluvial
AP-6 | Pluvial
CV-2 | Ventilação
CV-3 | Ventilação

# IfcPipeFitting: Joelho 90- desce (39)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- desce; Classe: PVC Esgoto; Tipo: Joelho 90- desce
Pset_PipeFittingTypeCommon - Reference: Joelho 90- desce
Name | In | Indicação = Nome | Rede | PVC Esgoto - Joelho 90 - 40 mm
29 x  | TÉRREO | 40 mm | Esgoto | 1
6 x  | TÉRREO | 20 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 20 mm: 1
AP-3 | COBERTURA | 50 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
AP-4 | COBERTURA | 50 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
AP-5 | COBERTURA | 50 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1
AP-6 | COBERTURA | 50 mm | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Joelho 90 - 50 mm: 1

# IfcPipeFitting: Joelho 90- sobe (36)
In: TÉRREO
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90- sobe; Classe: PVC Esgoto; Tipo: Joelho 90- sobe; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Joelho 90- sobe
Name | Indicação = Nome | PVC Esgoto - Joelho 90 - 40 mm
29 x  | 40 mm | 1
6 x  | 20 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 20 mm: 1
 | 25 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 25 mm: 1

# IfcPipeFitting: Junção invertida
In: TÉRREO
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 100 mm x 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção invertida; Nome: 100 mm x 50 mm; Classe: PVC Esgoto; Tipo: Junção invertida; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Junção invertida
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Junção invertida - 100 mm x 50 mm: 1

# IfcPipeFitting: Junção simples (20)
In: TÉRREO
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples; Classe: PVC Esgoto; Tipo: Junção simples
Pset_PipeFittingTypeCommon - Reference: Junção simples
Name | Indicação = Nome | Rede | PVC Esgoto - Anel de borracha - 100mm - 4" | PVC Esgoto - Anel de borracha - 50mm - 2"
8 x  | 100 mm - 50 mm | Esgoto | 1 | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
4 x  | 40 mm x 40 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 40 mm x 40 mm: 1
4 x  | 100 mm- 100 mm | Esgoto | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
2 x  | 50 mm - 50 mm | Ventilação |  | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
2 x  | 50 mm - 50 mm | Esgoto |  | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1

# IfcPipeFitting: Luva + Bucha de redução sold. curta (27)
In: FORRO
Type - PredefinedType: TRANSITION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva + Bucha de redução sold. curta; Classe: PVC rígido soldável; Tipo: Luva + Bucha de redução sold. curta; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Luva + Bucha de redução sold. curta
Name | Indicação = Nome | PVC rígido soldável - Bucha de redução sold. curta - 32 mm - 25 mm = PVC rígido soldável - Luva soldável - 32 mm
22 x  | 32 mm - 25 mm | 1
5 x  | 60 mm - 50 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 60 mm - 50 mm: 1; PVC rígido soldável - Luva soldável - 60 mm: 1

# IfcPipeFitting: Luva de redução soldável
In: TÉRREO
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 25 mm - 20 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva de redução soldável; Nome: 25 mm - 20 mm; Classe: PVC rígido soldável; Tipo: Luva de redução soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Luva de redução soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva de redução soldável - 25 mm - 20 mm: 1

# IfcPipeFitting: Luva soldável, AF-10
In: TÉRREO
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Indicação: 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva soldável; Nome: 25 mm; Classe: PVC rígido soldável; Tipo: Luva soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Luva soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 25 mm: 1

# IfcPipeFitting: Ramais de Ventilação (9)
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Ramal de ventilação; Descrição: Ramais de Ventilação; Classe: PVC Esgoto; Tipo: Ramais de Ventilação; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Ramais de Ventilação
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 3; PVC Esgoto - Joelho 90 - 50 mm: 1; PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1
Name | Indicação = Nome
7 x  | 50mm-50mm-45º
2 x  | 50mm-50mm-90º

# IfcPipeFitting: Redução excêntrica - superior
In: TÉRREO
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 100 mm - 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Redução excêntrica- superior; Nome: 100 mm - 50 mm; Classe: PVC Esgoto; Tipo: Redução excêntrica - superior; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Redução excêntrica - superior
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Redução excêntrica - 100 mm - 50 mm: 1

# IfcPipeFitting: Te 90 soldável (26)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável; Classe: PVC rígido soldável; Tipo: Te 90 soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável
Name | In | Indicação = Nome | PVC rígido soldável - Tê 90 soldável - 32 mm
4 x  | TÉRREO | 25 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 25 mm: 1
 | TÉRREO | 50 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 50 mm: 1
16 x  | FORRO | 32 mm | 1
2 x  | FORRO | 60 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 60 mm: 1
3 x  | COBERTURA | 25 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 25 mm: 1

# IfcPipeFitting: Te 90 soldável (centro) (11)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável; Classe: PVC rígido soldável; Tipo: Te 90 soldável (centro)
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável (centro)
Name | In | Indicação = Nome | Rede | PVC rígido soldável - Tê 90 soldável - 25 mm
7 x  | TÉRREO | 25 mm | Água fria | 1
3 x  | FORRO | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 32 mm: 1
 | COBERTURA | 20 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 20 mm: 1

# IfcPipeFitting: Te sanitário- superior, CV-4
In: TÉRREO
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 50 mm -50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te sanitário- superior; Nome: 50 mm -50 mm; Classe: PVC Esgoto; Tipo: Te sanitário- superior; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Te sanitário- superior
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1

# IfcPipeSegment: Calha retangular
In: COBERTURA
Type - PredefinedType: GUTTER
AltoQi_Builder - Altura: 20 cm; Base: 45 cm; Comprimento máximo: 300 cm; Espessura: 0.15 cm; Indicação: 200 x 450; Inclinação: 1; Comprimento: 2352.57 cm
Identificação_Elemento - Nome: 200 mm x 450 mm; Classe: Calha metálica; Tipo: Calha retangular; Rede: Pluvial; Aplicação: Calha retangular aberta
Pset_PipeSegmentTypeCommon - Reference: Calha retangular
Pset_PipeSegmentTypeGutter - Slope: 0.01 rad
AltoQi_QiBuilder-Itens_Associados - Calha metálica - Calha retangular - 200 mm x 200 mm: 2352.57 cm

# IfcPipeSegment: Circular metálico (9)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm; Diâmetro interno: 12.5 cm; Diâmetro: ø4"; Espessura: 0.15 cm; Indicação: 125 mm; Inclinação: 1
Identificação_Elemento - Nome: 125 mm; Classe: Condutor pluvial; Tipo: Circular metálico; Rede: Pluvial; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Circular metálico; InnerDiameter: 12.5 cm; NominalDiameter: ø4"
Name | In | Comprimento (cm) | Condutor pluvial - Circular metálico - 125 mm (cm)
 | TÉRREO | 104.08 | 104.083
 | TÉRREO | 87.47 | 87.469
 | TÉRREO | 71.32 | 71.3245
 | FORRO | 270 | 270
 | FORRO | 250 | 250
 | FORRO | 290 | 290
3 x  | COBERTURA | 80 | 80

# IfcPipeSegment: Tubo multicamada (4)
In: TÉRREO
Type - PredefinedType: FLEXIBLESEGMENT
AltoQi_Builder - Comprimento máximo: 5000 cm; Diâmetro interno: 2 cm; Diâmetro: ø3/4"; Espessura: 0.25 cm; Indicação: ø25
Identificação_Elemento - Nome: 25 mm; Classe: PEX; Tipo: Tubo multicamada; Rede: Gás; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo multicamada; InnerDiameter: 2 cm; NominalDiameter: ø3/4"
Name | Comprimento (cm) | PEX - Tubo multicamada - 25 mm (cm)
 | 683.73 | 683.734
 | 673.73 | 673.734
 | 663.73 | 663.734
 | 670.83 | 670.833

# IfcPipeSegment: Tubo rígido c/ ponta e bolsa soldável (48)
In: TÉRREO
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 696 cm; Diâmetro interno: 2.5 cm; Espessura: 0.12 cm; Inclinação: 2
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta e bolsa soldável; Rede: Esgoto; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta e bolsa soldável; InnerDiameter: 2.5 cm
Name | Diâmetro = NominalDiameter | Indicação = Nome | Comprimento (cm) | PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 20mm (cm)
 | ø3/4" | 20 mm | 323.48 | 323.477
6 x  | ø3/4" | 20 mm | 325.6 | 325.6
 | ø3/4" | 20 mm | 14.83 | 14.8282
 | ø3/4" | 20 mm | 85.05 | 85.049
 | ø3/4" | 20 mm | 4.45 | 4.44573
 | ø3/4" | 20 mm | 7.59 | 7.59392
 | ø3/4" | 20 mm | 3.33 | 3.33212
 | ø3/4" | 20 mm | 5.67 | 5.66523
 | ø3/4" | 20 mm | 57.16 | 57.1573
 | ø3/4" | 20 mm | 8.85 | 8.84724
 | ø3/4" | 20 mm | 21.66 | 21.6585
 | ø3/4" | 20 mm | 47.58 | 47.5832
 | ø3/4" | 20 mm | 39.97 | 39.9658
 | ø3/4" | 20 mm | 57.91 | 57.9108
 | ø3/4" | 20 mm | 4.68 | 4.67856
 | ø3/4" | 20 mm | 82.41 | 82.4107
 | ø3/4" | 20 mm | 12.2 | 12.2018
 | ø3/4" | 20 mm | 2.66 | 2.65704
 | ø3/4" | 20 mm | 37.91 | 37.9058
 | ø3/4" | 20 mm | 220.46 | 220.461
 | ø3/4" | 20 mm | 63.3 | 63.3032
 | ø3/4" | 20 mm | 327.09 | 327.086
 | ø1" | 25 mm | 62.8 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 25 mm: 62.8 cm
 | ø1" | 25 mm | 17.5 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 25 mm: 17.5017 cm
 | ø3/4" | 20 mm | 517.68 | 517.678
 | ø3/4" | 20 mm | 40.4 | 40.3967
 | ø3/4" | 20 mm | 138.72 | 138.72
 | ø3/4" | 20 mm | 2.33 | 2.33008
 | ø3/4" | 20 mm | 115.55 | 115.547
 | ø3/4" | 20 mm | 11.96 | 11.9579
 | ø3/4" | 20 mm | 8.77 | 8.76882
 | ø3/4" | 20 mm | 18.41 | 18.408
 | ø3/4" | 20 mm | 89.11 | 89.1055
 | ø3/4" | 20 mm | 11.13 | 11.1292
 | ø3/4" | 20 mm | 26.79 | 26.795
 | ø3/4" | 20 mm | 85.68 | 85.6788
 | ø3/4" | 20 mm | 2.22 | 2.22226
 | ø3/4" | 20 mm | 11.08 | 11.0813
 | ø3/4" | 20 mm | 99.07 | 99.0731
 | ø3/4" | 20 mm | 9.68 | 9.67554
 | ø3/4" | 20 mm | 422.48 | 422.476
 | ø3/4" | 20 mm | 70.86 | 70.8564
 | ø3/4" | 20 mm | 18.36 | 18.3648

# IfcPipeSegment: Tubo rígido c/ ponta lisa (22)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 600 cm; Diâmetro interno: 4.75 cm; Diâmetro: ø2"; Espessura: 0.16 cm; Indicação: 50 mm
Identificação_Elemento - Nome: 50 mm - 2"; Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa; Rede: Ventilação; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa; InnerDiameter: 4.75 cm; NominalDiameter: ø2"
Name | In | Inclinação | Comprimento (cm) | PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2" (cm)
 | TÉRREO | 1 | 41.83 | 41.8323
 | TÉRREO | 1 | 112.69 | 112.693
 | TÉRREO | 1 | 75.38 | 75.3752
 | TÉRREO | 1 | 56.6 | 56.6019
 | TÉRREO | 1 | 96.23 | 96.2285
 | TÉRREO | 1 | 102.78 | 102.782
 | TÉRREO | 1 | 5.97 | 5.97205
 | TÉRREO | 1 | 47.53 | 47.5253
 | TÉRREO | 1 | 163.58 | 163.584
 | TÉRREO | 1 | 145.16 | 145.161
 | TÉRREO | 1 | 136 | 135.995
 | TÉRREO | 1 | 58.84 | 58.8371
 | TÉRREO | 1 | 109.94 | 109.938
 | TÉRREO | 1 | 56.66 | 56.6572
 | TÉRREO | 1 | 26.56 | 26.5597
 | TÉRREO | 1 | 33.48 | 33.4773
 | FORRO | 2 | 361.9 | 361.9
 | FORRO | 2 | 356.9 | 356.9
 | FORRO | 1 | 356.9 | 356.9
 | FORRO | 2 | 352.8 | 352.8
 | FORRO | 1 | 357.2 | 357.2
 | FORRO | 1 | 352.8 | 352.8

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (232)
In: TÉRREO
Type - PredefinedType: RIGIDSEGMENT
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa e luva simples; Rede: Esgoto; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa e luva simples
Name | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | PVC Esgoto - Luva - 40 mm | PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm (cm)
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 46.74 | 40 mm - 1.1/2" | 1 | 46.7372
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 8.12 | 40 mm - 1.1/2" | 1 | 8.12426
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 30.42 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 30.4249 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 21.36 | 40 mm - 1.1/2" | 1 | 21.3571
24 x  | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 60.6 | 40 mm - 1.1/2" | 1 | 60.6
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 156.78 | 40 mm - 1.1/2" | 1 | 156.78
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 224.5 | 40 mm - 1.1/2" | 1 | 224.504
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 123.26 | 40 mm - 1.1/2" | 1 | 123.26
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 68.43 | 40 mm - 1.1/2" | 1 | 68.4328
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 238.26 | 40 mm - 1.1/2" | 1 | 238.259
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 18.9 | 40 mm - 1.1/2" | 1 | 18.9017
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 6.01 | 40 mm - 1.1/2" | 1 | 6.00857
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 7.12 | 40 mm - 1.1/2" | 1 | 7.11673
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 13.62 | 40 mm - 1.1/2" | 1 | 13.6244
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 15.02 | 40 mm - 1.1/2" | 1 | 15.0224
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 47.01 | 40 mm - 1.1/2" | 1 | 47.0091
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 65.68 | 40 mm - 1.1/2" | 1 | 65.6804
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 17.97 | 40 mm - 1.1/2" | 1 | 17.9735
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 53.68 | 40 mm - 1.1/2" | 1 | 53.6767
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 7.97 | 40 mm - 1.1/2" | 1 | 7.96587
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 86.08 | 40 mm - 1.1/2" | 1 | 86.0757
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 47.79 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 47.7854 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 66.98 | 40 mm - 1.1/2" | 1 | 66.9784
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 12.09 | 40 mm - 1.1/2" | 1 | 12.0905
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 89.58 | 40 mm - 1.1/2" | 1 | 89.5828
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.62 | 40 mm - 1.1/2" | 1 | 10.6184
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 201.81 | 40 mm - 1.1/2" | 1 | 201.811
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.8 | 40 mm - 1.1/2" | 1 | 10.8018
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 91.41 | 40 mm - 1.1/2" | 1 | 91.4107
6 x  | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 65.6 | 40 mm - 1.1/2" | 1 | 65.6
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 14.27 | 40 mm - 1.1/2" | 1 | 14.2739
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 22.75 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 22.748 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 14.6 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 14.5968 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 96.38 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 96.3789 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 1 | 127.75 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 127.751 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 33.03 | 40 mm - 1.1/2" | 1 | 33.0327
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 1 | 121.75 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 121.747 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 1 | 298.81 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 298.811 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 100.06 | 40 mm - 1.1/2" | 1 | 100.063
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 28.87 | 40 mm - 1.1/2" | 1 | 28.8747
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 147.12 | 40 mm - 1.1/2" | 1 | 147.115
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 85.4 | 40 mm - 1.1/2" | 1 | 85.3958
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 21.21 | 40 mm - 1.1/2" | 1 | 21.2107
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 75.41 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 75.4137 cm
2 x  | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 1 | 97.9 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 97.9044 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 1 | 102.5 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 102.504 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 8.24 | 40 mm - 1.1/2" | 1 | 8.24397
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 31.98 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 31.9827 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 128.76 | 40 mm - 1.1/2" | 1 | 128.756
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 172.24 | 40 mm - 1.1/2" | 1 | 172.236
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 114.82 | 40 mm - 1.1/2" | 1 | 114.817
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.44 | 40 mm - 1.1/2" | 1 | 10.443
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 35.6 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 35.6048 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 64.54 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 64.5421 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 209.5 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 209.5 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 624.04 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 624.044 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 2
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 94.82 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 94.8187 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 84.15 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 84.1518 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 32.52 | 40 mm - 1.1/2" | 1 | 32.5233
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 68 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 67.9998 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 59.99 | 40 mm - 1.1/2" | 1 | 59.9852
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 27.59 | 40 mm - 1.1/2" | 1 | 27.5902
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 57.74 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 57.7378 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 105.91 | 40 mm - 1.1/2" | 1 | 105.906
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 102.64 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 102.639 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 23.21 | 40 mm - 1.1/2" | 1 | 23.2074
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 88.16 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 88.1647 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 81.79 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 81.793 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 58.37 | 40 mm - 1.1/2" | 1 | 58.3685
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 79.65 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 79.6489 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 31.69 | 40 mm - 1.1/2" | 1 | 31.687
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 28.74 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 28.7442 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 65.49 | 40 mm - 1.1/2" | 1 | 65.4894
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 37.16 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 37.1617 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 161.44 | 40 mm - 1.1/2" | 1 | 161.441
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 50.45 | 40 mm - 1.1/2" | 1 | 50.4487
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9.49 | 40 mm - 1.1/2" | 1 | 9.49117
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 169.21 | 40 mm - 1.1/2" | 1 | 169.208
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 67.86 | 40 mm - 1.1/2" | 1 | 67.8551
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 25.6 | 40 mm - 1.1/2" | 1 | 25.6047
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 92.22 | 40 mm - 1.1/2" | 1 | 92.219
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 32.72 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 32.7249 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.02 | 40 mm - 1.1/2" | 1 | 10.017
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 49.59 | 40 mm - 1.1/2" | 1 | 49.5895
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 3.79 | 40 mm - 1.1/2" | 1 | 3.79418
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 316.94 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 316.94 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 60.37 | 40 mm - 1.1/2" | 1 | 60.3716
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 42.64 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 42.6364 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 95.89 | 40 mm - 1.1/2" | 1 | 95.8932
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 71.5 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 71.4992 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 140.77 | 40 mm - 1.1/2" | 1 | 140.768
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 288.9 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 288.899 cm; PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 61.38 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 61.3791 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 47.64 | 40 mm - 1.1/2" | 1 | 47.6354
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 45.17 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 45.1715 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 206.24 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 206.242 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 143.28 | 40 mm - 1.1/2" | 1 | 143.284
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 150.56 | 40 mm - 1.1/2" | 1 | 150.564
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 56.84 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 56.8445 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9.41 | 40 mm - 1.1/2" | 1 | 9.41362
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 116.62 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 116.621 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 18.09 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 18.092 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 90.89 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 90.893 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 181.44 | 40 mm - 1.1/2" | 1 | 181.441
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 132.24 | 40 mm - 1.1/2" | 1 | 132.241
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 20.14 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 20.1374 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 7.93 | 40 mm - 1.1/2" | 1 | 7.92548
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 12.97 | 40 mm - 1.1/2" | 1 | 12.968
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 151.62 | 40 mm - 1.1/2" | 1 | 151.624
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 128.14 | 40 mm - 1.1/2" | 1 | 128.136
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 6.15 | 40 mm - 1.1/2" | 1 | 6.14677
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 325.1 | 40 mm - 1.1/2" | 1 | 325.105
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 57.34 | 40 mm - 1.1/2" | 1 | 57.3431
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 233.07 | 40 mm - 1.1/2" | 1 | 233.075
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 448.13 | 40 mm - 1.1/2" | 1 | 448.132
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 231.33 | 40 mm - 1.1/2" | 1 | 231.334
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 96.32 | 40 mm - 1.1/2" | 1 | 96.3222
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 250.06 | 40 mm - 1.1/2" | 1 | 250.06
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 396.02 | 40 mm - 1.1/2" | 1 | 396.021
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 458.25 | 40 mm - 1.1/2" | 1 | 458.249
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 57.55 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 57.5524 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 50.22 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 50.2179 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 6.21 | 40 mm - 1.1/2" | 1 | 6.20681
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 45.8 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 45.8047 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.49 | 40 mm - 1.1/2" | 1 | 10.4935
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 35.08 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 35.0826 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 20.5 | 40 mm - 1.1/2" | 1 | 20.4955
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 168.54 | 40 mm - 1.1/2" | 1 | 168.538
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 210.47 | 40 mm - 1.1/2" | 1 | 210.472
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 134.62 | 40 mm - 1.1/2" | 1 | 134.617
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 145.75 | 40 mm - 1.1/2" | 1 | 145.748
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 128.78 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 128.78 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 70.82 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 70.8224 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 92.43 | 40 mm - 1.1/2" | 1 | 92.4282
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 152.67 | 40 mm - 1.1/2" | 1 | 152.672
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 8.31 | 40 mm - 1.1/2" | 1 | 8.3054
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 18.65 | 40 mm - 1.1/2" | 1 | 18.654
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 205.33 | 40 mm - 1.1/2" | 1 | 205.332
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 276.18 | 40 mm - 1.1/2" | 1 | 276.184
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 420.8 | 40 mm - 1.1/2" | 1 | 420.8
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 56.58 | 40 mm - 1.1/2" | 1 | 56.5765
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9 | 40 mm - 1.1/2" | 1 | 9.00487
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 279.81 | 40 mm - 1.1/2" | 1 | 279.814
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 37.83 | 40 mm - 1.1/2" | 1 | 37.8315
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 171.42 | 40 mm - 1.1/2" | 1 | 171.419
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 31.02 | 40 mm - 1.1/2" | 1 | 31.019
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 44.61 | 40 mm - 1.1/2" | 1 | 44.6115
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 395.44 | 40 mm - 1.1/2" | 1 | 395.436
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 19.33 | 40 mm - 1.1/2" | 1 | 19.3329
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 238.96 | 40 mm - 1.1/2" | 1 | 238.961
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 54.31 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 54.3136 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 11.23 | 40 mm - 1.1/2" | 1 | 11.2267
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 152.65 | 40 mm - 1.1/2" | 1 | 152.646
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 409.18 | 40 mm - 1.1/2" | 1 | 409.179
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 74.57 | 40 mm - 1.1/2" | 1 | 74.5749
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 721.11 | 40 mm - 1.1/2" | 1 | 721.112
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 81.94 | 40 mm - 1.1/2" | 1 | 81.9422
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.75 | 40 mm - 1.1/2" | 1 | 10.7529
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 188.51 | 40 mm - 1.1/2" | 1 | 188.511
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 697.08 | 40 mm - 1.1/2" | 1 | 697.078
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 102.29 | 40 mm - 1.1/2" | 1 | 102.286
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 91.2 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 91.1984 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 89.83 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 89.8294 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 29.11 | 40 mm - 1.1/2" | 1 | 29.1106
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 15.04 | 40 mm - 1.1/2" | 1 | 15.0436
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 112.82 | 40 mm - 1.1/2" | 1 | 112.817
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 102.82 | 40 mm - 1.1/2" | 1 | 102.823
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 61.02 | 40 mm - 1.1/2" | 1 | 61.015
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 6.32 | 40 mm - 1.1/2" | 1 | 6.31858
