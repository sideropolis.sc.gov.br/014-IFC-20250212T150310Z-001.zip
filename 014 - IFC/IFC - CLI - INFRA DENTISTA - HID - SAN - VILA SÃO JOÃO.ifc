Properties of the parts of a building model (IFC4), part 2 of 2

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (232)
Name | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | PVC Esgoto - Luva - 40 mm | PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm (cm)
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 192.68 | 40 mm - 1.1/2" | 1 | 192.683
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 15.3 | 40 mm - 1.1/2" | 1 | 15.3033
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 146.04 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 146.042 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 260.18 | 40 mm - 1.1/2" | 1 | 260.182
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 122.96 | 40 mm - 1.1/2" | 1 | 122.964
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 6.4 | 40 mm - 1.1/2" | 1 | 6.39672
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 8.73 | 40 mm - 1.1/2" | 1 | 8.73201
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 40.4 | 40 mm - 1.1/2" | 1 | 40.3989
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 10.13 | 40 mm - 1.1/2" | 1 | 10.132
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 5.93 | 40 mm - 1.1/2" | 1 | 5.93469
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 48.4 | 40 mm - 1.1/2" | 1 | 48.3991
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 28.7 | 40 mm - 1.1/2" | 1 | 28.6989
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 33.41 | 40 mm - 1.1/2" | 1 | 33.4084
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 74.21 | 40 mm - 1.1/2" | 1 | 74.2127
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 29.03 | 40 mm - 1.1/2" | 1 | 29.0298
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 14.14 | 40 mm - 1.1/2" | 1 | 14.145
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 110.63 | 40 mm - 1.1/2" | 1 | 110.633
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 52.03 | 40 mm - 1.1/2" | 1 | 52.0338
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 172.69 | 40 mm - 1.1/2" | 1 | 172.693
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 94.58 | 40 mm - 1.1/2" | 1 | 94.584
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 50.16 | 40 mm - 1.1/2" | 1 | 50.1574
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 169.75 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 169.754 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 86.75 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 86.7513 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 495.82 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 495.823 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 130.64 | 40 mm - 1.1/2" | 1 | 130.637
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 79.62 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 79.6172 cm
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 182.41 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 182.408 cm
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 63.18 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 63.1786 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9.02 | 40 mm - 1.1/2" | 1 | 9.01777
 | 296.5 | 4.75 | ø2" | 0.16 | 50 mm | 2 | 496.4 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 496.398 cm; PVC Esgoto - Anel de borracha - 50mm - 2": 1
 | 295.1 | 9.8 | ø4" | 0.18 | 100 mm | 1 | 110.66 | 100 mm - 4" | Código para composição de custos - SINAPI: 89714; CODIGO SINAPE - NUMERO: 89714; Orçamento - Código SINAPI: 89714; AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 110.662 cm
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9.57 | 40 mm - 1.1/2" | 1 | 9.56553
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 441.42 | 40 mm - 1.1/2" | 1 | 441.421
 | 599.8 | 3.76 | ø1 1/2" | 0.12 | 40 mm | 2 | 9.24 | 40 mm - 1.1/2" | 1 | 9.24198

# IfcPipeSegment: Tubos - diâmetro interno comercial (444)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm
Identificação_Elemento - Classe: PVC rígido soldável; Tipo: Tubos - diâmetro interno comercial; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubos - diâmetro interno comercial
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação = Nome | Comprimento (cm) | Rede | PVC rígido soldável - Tubos - 25 mm (cm)
12 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 57.9 | Água fria | 57.9
3 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 3.17 | Água fria | 3.175
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 14.32 | Água fria | 14.3154
21 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 33.9 | Água fria | 33.9
22 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 93.9 | Água fria | 93.9
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 32.08 | Água fria | 32.0788
25 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 15.15 | Água fria | 15.15
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 35.5 | Água fria | 35.5044
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 48.3 | Água fria | 48.3019
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 58.5 | Água fria | 58.5
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 156 | Água fria | 156.002
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 41.38 | Água fria | 41.3807
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 3.82 | Água fria | 3.81595
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 47.9 | Água fria | 47.9
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 218.58 | Água fria | 218.58
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 13.95 | Água fria | 13.951
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 9.78 | Água fria | 9.77919
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 60.42 | Água fria | 60.4239
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 25.91 | Água fria | 25.9057
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 8.61 | Água fria | 8.60954
2 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 52.3 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 52.3 cm
2 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 100.31 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 100.315 cm
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 46.4 | Água fria | 46.4
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 18.76 | Água fria | 18.7624
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 17.25 | Água fria | 17.25
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 22.1 | Água fria | 22.1
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 95.7 | Água fria | 95.7
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 26.92 | Água fria | 26.9161
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 14.18 | Água fria | 14.1789
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 195.78 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 195.779 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 9.48 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 9.47891 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 150.5 | Água fria | 150.5
5 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 7 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 7 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 94.4 | Água fria | 94.3996
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 18.83 | Água fria | 18.8259
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 152.15 | Água fria | 152.154
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 38.51 | Água fria | 38.5069
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 16.42 | Água fria | 16.4211
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 209.09 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 209.086 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 9.72 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 9.72109 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 86.85 | Água fria | 86.8481
3 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 96 | Água fria | 96
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 124.35 | Água fria | 124.347
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 32.91 | Água fria | 32.9061
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 9.26 | Água fria | 9.26223
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 36.61 | Água fria | 36.6096
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 28.64 | Água fria | 28.6381
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 28.5 | Água fria | 28.5
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 73.38 | Água fria | 73.3763
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 37.11 | Água fria | 37.105
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 15.45 | Água fria | 15.453
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 3.57 | Água fria | 3.56631
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 14.69 | Água fria | 14.6874
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 10.12 | Água fria | 10.1221
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 5.57 | Água fria | 5.56584
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 145.58 | Água fria | 145.578
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 10.15 | Água fria | 10.15
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 17.53 | Água fria | 17.5259
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 5.69 | Água fria | 5.69041
3 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 56.4 | Água fria | 56.4
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 131.38 | Água fria | 131.381
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 18.98 | Água fria | 18.9844
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 7.72 | Água fria | 7.72183
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 47.3 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 47.3 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 102.61 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 102.615 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 52.9 | Água fria | 52.9
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 93.43 | Água fria | 93.4324
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 38.9 | Água fria | 38.9
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 41.33 | Água fria | 41.3313
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 117.88 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 117.883 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 12.27 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 12.2669 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 191.86 | Água fria | 191.862
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 8.24 | Água fria | 8.2372
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 2.5 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 2.5 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 95.58 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 95.5796 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 92.16 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 92.1624 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 10.15 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 10.1526 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 5.4 | Água fria | 5.40014
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 107.54 | Água fria | 107.54
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 42.26 | Água fria | 42.2642
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 137.9 | Água fria | 137.9
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 10.94 | Água fria | 10.9425
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 77.95 | Água fria | 77.9464
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 46.35 | Água fria | 46.3536
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 8 | Água fria | 7.99762
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 52.77 | Água fria | 52.7693
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 29.58 | Água fria | 29.582
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 74.28 | Água fria | 74.2823
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 2.45 | Água fria | 2.45386
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 13.96 | Água fria | 13.9616
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 32.85 | Água fria | 32.8512
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 9.21 | Água fria | 9.20727
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 8.03 | Água fria | 8.03496
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 21.39 | Água fria | 21.3909
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 177.41 | Água fria | 177.41
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 16.99 | Água fria | 16.9924
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 35.4 | Água fria | 35.4
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 61.02 | Água fria | 61.0232
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 3.63 | Água fria | 3.62608
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 19.69 | Água fria | 19.6902
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 3.46 | Água fria | 3.46499
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 40.37 | Água fria | 40.3734
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 40.19 | Água fria | 40.1881
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 4.4 | Água fria | 4.4
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 39.82 | Água fria | 39.8184
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 22.84 | Água fria | 22.8391
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 132.01 | Água fria | 132.013
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 3.89 | Água fria | 3.8921
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 61.31 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 61.31 cm
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 91 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 91 cm
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | -11.63 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: -11.6282 cm
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 15.5 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 15.5 cm
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 18.37 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 18.3718 cm
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 21.91 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 21.9069 cm
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 282.58 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 282.578 cm
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 3419.47 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 3419.47 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 1.62 | Água fria | 1.61507
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 75.5 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 75.5 cm
2 x  | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 4.78 | Água fria | 4.78498
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 26.62 | Água fria | 26.6221
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 8.33 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 8.33167 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 10.83 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 10.8323 cm
2 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 155.31 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 155.315 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 5.35 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 5.34694 cm
 | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 26.5 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 26.5048 cm
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 25.5 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 25.5 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 36.2 | Água fria | 36.2027
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 25.72 | Água fria | 25.7221
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 64.3 | Água fria | 64.3
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 24.3 | Água fria | 24.3
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 11.15 | Água fria | 11.1526
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 35.16 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 35.1592 cm
2 x  | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 212.73 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 212.733 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 20.8 | Água fria | 20.797
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 891.49 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 891.49 cm
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 11 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 11 cm
 | TÉRREO | 1.7 | ø1/2" | 0.15 | 20 mm | 21.21 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 21.2116 cm
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 21.33 | Água fria | 21.3269
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 24.86 | Água fria | 24.8551
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 132.8 | Água fria | 132.8
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 125.48 | Água fria | 125.483
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 38.53 | Água fria | 38.5312
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 205.96 | Água fria | 205.958
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 4.86 | Água fria | 4.86118
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 31.95 | Água fria | 31.9476
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 46.63 | Água fria | 46.6291
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 22.98 | Água fria | 22.9842
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 279.57 | Água fria | 279.571
 | TÉRREO | 2.16 | ø3/4" | 0.17 | 25 mm | 38.2 | Água fria | 38.1962
4 x  | TÉRREO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 6.7 | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 6.69508 cm; AltoQi_Builder - Inclinação: 1
18 x  | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 26.4 | Água fria | 26.4
2 x  | FORRO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 20 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 20 cm
3 x  | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 36.4 | Água fria | 36.4
 | FORRO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 30 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 30 cm
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 590.21 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 590.207 cm
2 x  | FORRO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 17.3 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 17.3 cm
2 x  | FORRO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 12.57 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 12.5728 cm
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 15.98 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 15.9787 cm
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 24.55 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 24.5506 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 27.25 | Água fria | 27.2528
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 16.65 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 16.6506 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 102.5 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 102.504 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 13.31 | Água fria | 13.3059
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 352.07 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 352.065 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 248.19 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 248.188 cm
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 366.21 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 366.212 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 105.1 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 105.096 cm
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 349.46 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 349.455 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 12.14 | Água fria | 12.1372
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 72.18 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 72.1795 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 23.86 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 23.8575 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 168.62 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 168.619 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 94.17 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 94.1733 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 76.97 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 76.971 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 14.61 | Água fria | 14.6096
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 169.63 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 169.635 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 109.89 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 109.886 cm
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 494.5 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 494.502 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 66.03 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 66.0273 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 371.09 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 371.091 cm
 | FORRO | 1.7 | ø1/2" | 0.15 | 20 mm | 381 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 381 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 297.32 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 297.325 cm
 | FORRO | 1.7 | ø1/2" | 0.15 | 20 mm | 56.48 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 56.476 cm
 | FORRO | 1.7 | ø1/2" | 0.15 | 20 mm | 651.5 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 651.499 cm
 | FORRO | 1.7 | ø1/2" | 0.15 | 20 mm | 143.28 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 143.281 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 13.06 | Água fria | 13.0637
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 53.86 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 53.8613 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 305.38 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 305.381 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 191.88 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 191.883 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 11.19 | Água fria | 11.1931
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 47.8 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 47.8041 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 116.23 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 116.233 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 213.53 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 213.535 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 189.88 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 189.883 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 13.47 | Água fria | 13.4726
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 10.75 | Água fria | 10.7479
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 217.58 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 217.577 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 75.2 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 75.1978 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 54.1 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 54.0954 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 19.12 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 19.1236 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 91.46 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 91.4566 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 11.99 | Água fria | 11.987
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 69.24 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 69.2415 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 47.79 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 47.7895 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 134.65 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 134.649 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 97.54 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 97.5372 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 264.42 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 264.421 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 51.26 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 51.2576 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 11.27 | Água fria | 11.2706
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 43.91 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 43.91 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 16.94 | Água fria | 16.9419
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 250.92 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 250.92 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 640.06 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 640.063 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 9.13 | Água fria | 9.12506
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 214.45 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 214.448 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 826.64 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 826.637 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 114.21 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 114.21 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 11.76 | Água fria | 11.7575
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 11.12 | Água fria | 11.1224
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 151.75 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 151.755 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 147.49 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 147.495 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 434.43 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 434.432 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 34.85 | Água fria | 34.8463
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 112.19 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 112.192 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 35 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 34.9975 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 134.59 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 134.589 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 43.33 | Água fria | 43.333
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 124.3 | Água fria | 124.3
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 63 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 63.0046 cm
4 x  | FORRO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 231.9 | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 231.9 cm; AltoQi_Builder - Inclinação: 1
3 x  | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 464 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 463.995 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 232.8 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 232.801 cm
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 113.53 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 113.527 cm
3 x  | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 12.23 | Água fria | 12.2286
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 18.55 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 18.55 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 114.27 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 114.275 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 236.75 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 236.75 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 14.12 | Água fria | 14.1157
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 18.71 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 18.7079 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 460.93 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 460.925 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 573 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 573.003 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 15.3 | Água fria | 15.2988
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 90.09 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 90.0933 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 103.05 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 103.046 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 70.23 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 70.2304 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 51.02 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 51.0242 cm
 | FORRO | 2.16 | ø3/4" | 0.17 | 25 mm | 15.53 | Água fria | 15.5331
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 42 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 42 cm
 | FORRO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 11.86 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 11.8553 cm
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 94.15 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 94.1505 cm
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 21.5 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 21.5 cm
 | FORRO | 5.34 | ø2" | 0.33 | 60 mm | 86.25 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 86.2505 cm
2 x  | FORRO | 4.4 | ø1 1/2" | 0.3 | 50 mm | 11.67 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 11.668 cm
 | FORRO | 2.78 | ø1" | 0.21 | 32 mm | 168.39 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 168.39 cm
 | COBERTURA | 5.34 | ø2" | 0.33 | 60 mm | 46.9 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 46.8981 cm
2 x  | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 72.9 | Água fria | 72.9
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 10.32 | Água fria | 10.3248
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 48.49 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 48.4881 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 36.85 | Água fria | 36.8514
2 x  | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 15.8 | Água fria | 15.7979
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 36.25 | Água fria | 36.2514
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 152.72 | Água fria | 152.719
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 31.65 | Água fria | 31.6509
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 52.8 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 52.7956 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 10.42 | Água fria | 10.4153
2 x  | COBERTURA | 5.34 | ø2" | 0.33 | 60 mm | 108.28 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 108.281 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 9.51 | Água fria | 9.5126
 | COBERTURA | 5.34 | ø2" | 0.33 | 60 mm | 199.68 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 199.678 cm
2 x  | COBERTURA | 5.34 | ø2" | 0.33 | 60 mm | 112.77 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 112.768 cm
 | COBERTURA | 5.34 | ø2" | 0.33 | 60 mm | 20.73 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 20.733 cm
3 x  | COBERTURA | 5.34 | ø2" | 0.33 | 60 mm | 52.6 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 52.6 cm
3 x  | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 65.2 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 65.2 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 32.85 | Água fria | 32.8509
2 x  | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 116.17 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 116.171 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 241.91 | Água fria | 241.909
 | COBERTURA | 1.7 | ø1/2" | 0.15 | 20 mm | 76 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 76 cm
 | COBERTURA | 1.7 | ø1/2" | 0.15 | 20 mm | 124.92 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 124.917 cm
 | COBERTURA | 1.7 | ø1/2" | 0.15 | 20 mm | 87.66 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 87.663 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 111.87 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 111.869 cm
3 x  | COBERTURA | 4.4 | ø1 1/2" | 0.3 | 50 mm | 31.74 | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 31.742 cm; AltoQi_Builder - Inclinação: 1
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 23.21 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 23.2078 cm
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | 50 mm | 18.45 | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 18.4529 cm; AltoQi_Builder - Inclinação: 1
 | COBERTURA | 4.4 | ø1 1/2" | 0.3 | 50 mm | 17.82 | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 17.8177 cm; AltoQi_Builder - Inclinação: 1
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 9 | Água fria | 9.00317
4 x  | COBERTURA | 4.4 | ø1 1/2" | 0.3 | 50 mm | 76.9 | Pluvial | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 76.9 cm; AltoQi_Builder - Inclinação: 1
2 x  | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 120.66 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 120.658 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 81.16 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 81.163 cm
 | COBERTURA | 5.34 | ø2" | 0.33 | 60 mm | 45.58 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 45.578 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 234.41 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 234.412 cm
 | COBERTURA | 5.34 | ø2" | 0.33 | 60 mm | 17.04 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 17.0438 cm
 | COBERTURA | 5.34 | ø2" | 0.33 | 60 mm | 98.85 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 98.8542 cm
 | COBERTURA | 5.34 | ø2" | 0.33 | 60 mm | 66.84 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 66.837 cm
 | COBERTURA | 1.7 | ø1/2" | 0.15 | 20 mm | 149.84 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 149.844 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 48.64 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 48.6396 cm
2 x  | COBERTURA | 1.7 | ø1/2" | 0.15 | 20 mm | 69.71 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 69.706 cm
2 x  | COBERTURA | 1.7 | ø1/2" | 0.15 | 20 mm | 59.5 | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 20 mm: 59.5 cm

# IfcSanitaryTerminal: Bebedouro com joelho de 90º
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.1; Indicação: BE; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Bebedouro com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Bebedouro com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Bebedouro com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Bebedouro - 25mmx 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcSanitaryTerminal: Chuveiro (2)
In: TÉRREO
Type - PredefinedType: SHOWER
AltoQi_Builder - Vazão de projeto (l/s): 0.1; Indicação: CH; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Chuveiro; Nome: 25mm x 3/4"; Classe: PVC rígido soldável; Tipo: Chuveiro; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Chuveiro
AltoQi_QiBuilder-Itens_Associados - Aparelho - Chuveiro - 25mm x 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1

# IfcSanitaryTerminal: Chuveiro Residencial (2)
In: TÉRREO
Type - PredefinedType: SHOWER
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Chuveiro Residencial; Nome: 40mm; Classe: PVC Esgoto; Tipo: Chuveiro Residencial; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Chuveiro Residencial
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo sifonado alt. reg. saída 40 - 100 mm - 40 mm: 1; PVC Esgoto - Curva 90 curta - 40 mm: 1

# IfcSanitaryTerminal: Ducha Higiênica com Joelho de 90º
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.2; Indicação: DH; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Ducha Higiênica; Nome: 25 mm x 1/2"; Classe: PVC rígido soldável; Tipo: Ducha Higiênica com Joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Ducha Higiênica com Joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Ducha higiênica - 25mm x 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcSanitaryTerminal: Lavatório Residencial com sifão (29)
In: TÉRREO
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Lavatório Residencial com sifão; Nome: 40mm; Classe: PVC Esgoto; Tipo: Lavatório Residencial com sifão; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório Residencial com sifão
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm

# IfcSanitaryTerminal: Lavatório com joelho de 90º (26)
In: TÉRREO
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Vazão de projeto (l/s): 0.15; Indicação: LV; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Lavatório com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Lavatório com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de lavatório - 25 mm - 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcSanitaryTerminal: Pia de cozinha com joelho de 90º
In: TÉRREO
Type - PredefinedType: SINK
AltoQi_Builder - Vazão de projeto (l/s): 0.25; Indicação: PIA; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Pia de cozinha com joelho de 90º; Nome: 25 mm - 3/4"; Classe: PVC rígido soldável; Tipo: Pia de cozinha com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Pia de cozinha com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Pia de Cozinha - 25mm - 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1

# IfcSanitaryTerminal: Saídas livres (2)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0; Indicação: Saída; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Saídas livres; Classe: PVC rígido soldável; Tipo: Saídas livres; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Saídas livres
AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
Name | In | Nome
 | TÉRREO | 20 mm
 | COBERTURA | 25 mm

# IfcSanitaryTerminal: Torneira de Jardim com Tê 90°
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.2; Indicação: TJ; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Torneira de jardim com tê 90; Nome: 20 mm x 1/2"; Classe: PVC rígido soldável; Tipo: Torneira de Jardim com Tê 90°; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Torneira de Jardim com Tê 90°
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Jardim - 20mm x 1/2": 1; PVC soldável azul c/ bucha latão - Tê sold c/ bucha latão bolsa central - 20 mm- 1/2": 1

# IfcSanitaryTerminal: Torneira de Jardim com joelho 90°
In: TÉRREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.2; Indicação: TJ; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Torneira de Jardim; Nome: 20 mm x 1/2"; Classe: PVC rígido soldável; Tipo: Torneira de Jardim com joelho 90°; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Torneira de Jardim com joelho 90°
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Jardim - 20mm x 1/2": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 20 mm - 1/2": 1

# IfcSanitaryTerminal: Vaso Sanitário c/ curva 90º (6)
In: TÉRREO
Type - PredefinedType: WCSEAT
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Vaso Sanitário c/ curva 90º; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Vaso Sanitário c/ curva 90º; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Vaso Sanitário c/ curva 90º
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1

# IfcSanitaryTerminal: Vaso Sanitário com válvula de descarga (6)
In: TÉRREO
Type - PredefinedType: WCSEAT
AltoQi_Builder - Vazão de projeto (l/s): 1.7; Indicação: VS; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Vaso Sanitário com válvula de descarga; Nome: 1 1/2"; Classe: PVC rígido soldável; Tipo: Vaso Sanitário com válvula de descarga; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Vaso Sanitário com válvula de descarga
AltoQi_QiBuilder-Itens_Associados - Aparelho - Vaso Sanitário p/ Válvula de Descarga de 1 1/2" - 40mm - 1 1/2": 1

# IfcStackTerminal: Terminal de ventilação- coluna (6)
In: FORRO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Terminal de ventilação- coluna; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Terminal de ventilação- coluna; Rede: Ventilação
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Terminal de ventilação - 50 mm: 1
Name
CV-1
CV-2
CV-3
CV-4
CV-5
CV-6

# IfcTank: Caixa d'água (2)
In: COBERTURA
Type - PredefinedType: STORAGE
AltoQi_Builder - Volume efetivo (l): 2000; Altura: 110.6 cm; Diâmetro: 182.15 cm; Indicação: 2000L; Posição: Direta; % do volume do reservatório: 50; Localização: Superior; Volume da RTI (m³): 0; Volume da edificação (m³/dia): 0.22; Volume útil estimado (m³): 0.11; Volume (m³): 2
Identificação_Elemento - Aplicação: Reservatório cilíndrico; Descrição: Reservatório 2000L; Nome: 2000L; Classe: Reservatório cilíndrico; Tipo: Caixa d'água; Rede: Água fria
Pset_TankTypeCommon - Reference: Caixa d'água; NominalCapacity: 2; NominalDepht: 110.6 cm; NominalLenghtOrDiameter: 182.15 cm
AltoQi_QiBuilder-Itens_Associados - Reservatório cilíndrico - Polietileno - 2000 L: 1
Name
RCi1
RCi2

# IfcValve: Registro bruto gaveta Industrial c/PVC soldável (8)
In: COBERTURA
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro bruto gaveta Industrial c/PVC soldável; Classe: PVC rígido soldável; Tipo: Registro bruto gaveta Industrial c/PVC soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro bruto gaveta Industrial c/PVC soldável
Name | Nome
2 x  | 3/4" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 3/4": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4": 2
3 x  | 2" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 60 mm - 2": 2
3 x  | 1" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 1": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 32 mm - 1": 2

# IfcValve: Registro de Pressão com PVC soldável (2)
In: TÉRREO
Type - PredefinedType: REGULATING
AltoQi_Builder - Indicação: RP; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro de Pressão com PVC soldável; Nome: 25 mm - 3/4"; Classe: PVC rígido soldável; Tipo: Registro de Pressão com PVC soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro de Pressão com PVC soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Registro de pressão c/ canopla cromada - 3/4": 1; PVC misto soldável - Luva soldável c/ rosca - 25 mm -3/4": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4": 1

# IfcValve: Registro de gaveta c/canopla cromada c/PVC soldável (25)
In: TÉRREO
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro de gaveta c/canopla cromada c/PVC soldável; Nome: 3/4"; Classe: PVC rígido soldável; Tipo: Registro de gaveta c/canopla cromada c/PVC soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro de gaveta c/canopla cromada c/PVC soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 3/4": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4": 2

# IfcValve: Valvula de descarga c/PVC soldável (6)
In: TÉRREO
Type - PredefinedType: FLUSHING
AltoQi_Builder - Indicação: VD; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Valvula de descarga c/PVC soldável; Nome: 1.1/2"; Classe: PVC rígido soldável; Tipo: Valvula de descarga c/PVC soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Valvula de descarga c/PVC soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Válvula de descarga baixa pressão - 1.1/2": 1; PVC Acessórios - Bolsa de ligação p/ vaso sanitário - 1.1/2": 1; PVC Acessórios - Tubo de descarga VDE. - 38 mm: 1; PVC Acessórios - Tubo de ligação latão cromado c/ canopla p/ vaso Sa. - 38 mm: 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 1

# IfcWasteTerminal: Caixa Sifonada (16)
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Comprimento: 15.5 cm; Diâmetro: 15 cm; Indicação: 150x150x50; Posição: Direta
Identificação_Elemento - Aplicação: Caixa sifonada; Descrição: Caixa Sifonada; Nome: 150x150x50; Classe: PVC Esgoto; Tipo: Caixa Sifonada; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Caixa Sifonada
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x150x50: 1; PVC Esgoto - Anel de borracha - 50mm - 2": 1
Name | In
12 x  | TÉRREO
4 x  | COBERTURA

# IfcWasteTerminal: Caixas Inspeção Esgoto Simples (4)
In: TÉRREO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Comprimento: 80 cm; Largura: 80 cm; Indicação: CE- 60x 60cm; Posição: Direta
Identificação_Elemento - Aplicação: Caixa de alvenaria; Descrição: Caixas Inspeção Esgoto Simples; Nome: CE- 60x 60cm; Classe: Caixas de Passagem; Tipo: Caixas Inspeção Esgoto Simples; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Caixas Inspeção Esgoto Simples
AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de inspeção esgoto simples - CE- 60x60 cm: 1

# IfcWasteTerminal: Filtros, FA1
In: TÉRREO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta; Altura do vão livre: 30 cm; Contribuição de esgoto (L/dia): 650; Tempo de detenção (dia): 1; Volume útil estimado (m³): 1.04; Altura total do leito: 120 cm; Comprimento: 127 cm; Largura: 85 cm; Volume (m³): 1.3
Identificação_Elemento - Aplicação: Filtro anaeróbio; Nome: Filtro anaeróbio - concreto; Classe: Unidades de tratamento; Tipo: Filtros; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Filtros
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 254 cm; Unidades de tratamento - Brita - nº4: 1.2954 m3; Unidades de tratamento - Concreto - Concreto: 0.06996 m3

# IfcWasteTerminal: Sumidouros, SU1
In: TÉRREO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta; Altura da camada de brita: 30 cm; Taxa de aplicação diária (m³/m².dia): 0.13; Taxa de percolação (min/m): 100; Contribuição de esgoto (L/dia): 0; Altura: 150 cm
Identificação_Elemento - Aplicação: Sumidouro; Nome: Circular; Classe: Unidades de tratamento; Tipo: Sumidouros; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Sumidouros
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 15 cm; Unidades de tratamento - Argamassa - Argamassa: 0.067858 m3; Unidades de tratamento - Brita - nº3: 0.021206 m3; Unidades de tratamento - Tijolo - Furado: 34

# IfcWasteTerminal: Tanques sépticos, TS1
In: TÉRREO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta; Intervalo entre limpezas: 2 anos; Número de câmaras: Câmara única; Contribuição de esgoto (L/dia): 650; Contribuição de lodo (L/dia): 5; Taxa de acumul. do lodo (dias/intervalo): 105; Tempo de detenção (dia): 1; Volume útil estimado (m³): 2.175; Comprimento: 170 cm; Largura: 85 cm; Profundidade útil: 120 cm; Volume (m³): 1.73
Identificação_Elemento - Aplicação: Tanque séptico; Nome: Tanque séptico - concreto; Classe: Unidades de tratamento; Tipo: Tanques sépticos; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Tanques sépticos
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 120.4 cm; Unidades de tratamento - Alça - Ferro: 1; Unidades de tratamento - Concreto - Concreto: 1.3515 m3; Unidades de tratamento - Tampa - Hermética: 1
