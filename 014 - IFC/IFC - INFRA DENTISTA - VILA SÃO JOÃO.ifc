Properties of the parts of a building model (IFC4)

# File
Description: IFC4
Time: 2024-11-25T15:55:37
Made in: IfcPlusPlus

# IfcBuildingStorey, TÉRREO
LongName: TÉRREO; Elevation: 0 cm

# IfcPipeSegment: Tubo multicamada (4)
In: TÉRREO
Type - PredefinedType: FLEXIBLESEGMENT
AltoQi_Builder - Comprimento máximo: 5000 cm; Diâmetro interno: 2 cm; Diâmetro: ø3/4"; Espessura: 0.25 cm; Indicação: ø25
Identificação_Elemento - Nome: 25 mm; Classe: PEX; Tipo: Tubo multicamada; Rede: Gás; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo multicamada; InnerDiameter: 2 cm; NominalDiameter: ø3/4"
Name | Comprimento (cm) | PEX - Tubo multicamada - 25 mm (cm)
 | 683.73 | 683.734
 | 673.73 | 673.734
 | 663.73 | 663.734
 | 670.83 | 670.833
